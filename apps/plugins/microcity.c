/*
 * MicroCity for Rockbox -- portable trial port, 2026-10-10.
 * Original game, simulation and art: James Howard (jhhoward).
 * https://github.com/jhhoward/MicroCity
 * Upstream commit: ae265f1923e9ac9789df601bb438faa29b7ae339
 * Optional color art: James Howard's MicroCity-Pokitto, GPL v3.
 * https://github.com/jhhoward/MicroCity-Pokitto
 * Color upstream commit: 48b22356cdedb1778c6a1f51c1d809c9b432f0bb
 * Uses its complete tile set, logo and modified DawnBringer 16 palette.
 * Rockbox adaptation: OpenAI Codex, at the user's request.
 * SPDX-License-Identifier: GPL-3.0-only
 * Full upstream GPL v3 license is included at the end of this file.
 * The upstream 4x6 font is MIT licensed; its source credit is retained below.
 *
 * BUILD: Copy this file to apps/plugins/microcity.c. Add microcity.c to
 * apps/plugins/SOURCES guarded with
 * #if LCD_WIDTH >= 96 && LCD_HEIGHT >= 64
 * Optionally add microcity,games to apps/plugins/CATEGORIES. Build normally.
 * No external game assets, Arduino libraries, malloc, FPU or multicore needed.
 * Standard Rockbox pluginlib supplies generic actions and backlight helpers.
 * Keypads other than YP3 use pla_main_ctx in pluginlib_actions.c.
 *
 * CONTROLS: hold directions to move; short Select builds/confirms. Cancel
 * opens tools/back; Exit pauses. Double Left opens tools/back, Double Right
 * pauses, including on five-button YP3. The first arrow change is rolled back
 * for a recognized double tap (300 ms). Long Select has no game action.
 * Scroll wheels navigate menus; toolbar/terrain/budget accept all directions.
 * Touchscreens use Rockbox's 3x3 button mode and restore the prior mode on exit.
 * YP3_PAD has an explicit five-button context; other keypads use pla_main_ctx,
 * including remote contexts when available. PORT_CENTER_BUTTON can override
 * the YP3 center mask. A new Rockbox core must still support its own key driver.
 *
 * COLOR: define MICROCITY_COLOR for the developer's Pokitto color artwork.
 * Leave undefined for monochrome. Color requires HAVE_LCD_COLOR.
 * DISPLAY: bitmap LCDs >=96x64, including 128x64, 96x96, portrait/landscape,
 * grayscale and color. Integer scaling defaults to ceil(max(LCD size)/240),
 * with a logical viewport rounded down to 8 pixels, centered on the panel.
 * Override MICROCITY_SCALE if desired; logical dimensions must be 96x64 to
 * 240x240. Scrollable help/pause menus, a windowed toolbar and compact budget.
 *
 * MEMORY: logical-width * logical-height / 8 bytes for monochrome, or / 2 for
 * color, plus one physical-width conversion row. No heap or full RGB frame.
 * At 128x160: 2,560 bytes mono; 10,240 bytes color plus 256-byte RGB565 row.
 * The original full 48x48 world and simulation are retained. Rockbox's own
 * framebuffer, code/assets and stack are additional to these buffer counts.
 *
 * SAVES: one versioned, checksummed slot at PLUGIN_GAMES_DATA_DIR/microcity.sav.
 * Writes a temporary file then renames it. This is not Arduboy EEPROM format.
 * Save explicitly, or choose Save and quit. USB exit does not save silently.
 *
 * Port changes include bounded power-network traversal, portable saves,
 * clipped rendering, safe menu repeats, cancellable map preview, and fixes
 * for population accounting when bulldozing and a duplicated tax population.
 * VALIDATION: built with Rockbox 5a0fc3c6e9ecc2c876033a8088479e3886f3cc2a.
 * Host ASan/UBSan tests exercise simulation, saves, layouts and controls.
 * This is source-level portability, not a claim that every physical device
 * has been tested. Compile with your target toolchain for exact size/speed.
 */
#include "plugin.h"
#include "lib/pluginlib_actions.h"
#include "lib/helper.h"
#include "lib/playback_control.h"

/* The Pokitto color artwork is used on color LCDs; define MICROCITY_MONO to
 * force the monochrome art. */
#if defined(HAVE_LCD_COLOR) && !defined(MICROCITY_MONO) && !defined(MICROCITY_COLOR)
#define MICROCITY_COLOR
#endif
#if defined(MICROCITY_COLOR) && !defined(HAVE_LCD_COLOR)
#error MICROCITY_COLOR requires a Rockbox color LCD target
#endif

#if LCD_WIDTH < 96 || LCD_HEIGHT < 64
#error MicroCity requires a bitmap LCD of at least 96 x 64 pixels
#endif

/* AVR flash-access compatibility: assets are ordinary read-only C data. */
#define PROGMEM
#define pgm_read_byte(p) (*(const uint8_t *)(p))
#define pgm_read_word(p) (*(const uint16_t *)(p))
#define pgm_read_ptr(p) (*(p))
#define strlen_P(s) rb->strlen(s)

/* Bound the logical viewport to 240x240, preserving the engine's 8-bit
 * drawing coordinates. Integer pixel scaling keeps text readable on large
 * screens and prevents framebuffer RAM from growing with phone-sized LCDs. */
#ifndef MICROCITY_SCALE
#define MICROCITY_SCALE ((MAX(LCD_WIDTH,LCD_HEIGHT)+239)/240)
#endif
#define DISPLAY_SCALE MICROCITY_SCALE
#define DISPLAY_WIDTH ((LCD_WIDTH/DISPLAY_SCALE)/8*8)
#define DISPLAY_HEIGHT ((LCD_HEIGHT/DISPLAY_SCALE)/8*8)
#if DISPLAY_WIDTH < 96 || DISPLAY_HEIGHT < 64 || DISPLAY_WIDTH > 240 || DISPLAY_HEIGHT > 240
#error Choose MICROCITY_SCALE giving a logical viewport between 96x64 and 240x240
#endif
#define MAP_WIDTH 48
#define MAP_HEIGHT 48
#define TILE_SIZE 8
#define TILE_SIZE_SHIFT 3
#define MAX_SCROLL_X (MAP_WIDTH * TILE_SIZE - DISPLAY_WIDTH)
#define MAX_SCROLL_Y (MAP_HEIGHT * TILE_SIZE - DISPLAY_HEIGHT)

#define VISIBLE_TILES_X ((DISPLAY_WIDTH / TILE_SIZE) + 1)
#define VISIBLE_TILES_Y ((DISPLAY_HEIGHT / TILE_SIZE) + 1)

#define MAX_BUILDINGS 130

// How long a button has to be held before the first event repeats
#define INPUT_REPEAT_TIME 10

// When repeating, how long between each event is fired
#define INPUT_REPEAT_FREQUENCY 2

#define BULLDOZER_COST 1
#define ROAD_COST 10
#define POWERLINE_COST 5

#define FIRST_TERRAIN_TILE 1
#define FIRST_WATER_TILE 17
#define LAST_WATER_TILE (FIRST_WATER_TILE + 3)

#define FIRST_FIRE_TILE 232
#define LAST_FIRE_TILE (FIRST_FIRE_TILE + 3)

#define FIRST_ROAD_TILE 5
#define FIRST_ROAD_TRAFFIC_TILE (FIRST_ROAD_TILE + 16)
#define LAST_ROAD_TRAFFIC_TILE (FIRST_ROAD_TRAFFIC_TILE + 10)
#define FIRST_POWERLINE_TILE 53
#define FIRST_POWERLINE_ROAD_TILE 49

#define FIRST_ROAD_BRIDGE_TILE 32
#define FIRST_POWERLINE_BRIDGE_TILE 34

#define FIRST_BUILDING_TILE 224

#define FIRST_EDGE_TILE 79
#define NORTH_WEST_EDGE_TILE FIRST_EDGE_TILE
#define NORTH_EAST_EDGE_TILE (FIRST_EDGE_TILE + 16)
#define SOUTH_WEST_EDGE_TILE (FIRST_EDGE_TILE + 32)
#define SOUTH_EAST_EDGE_TILE (FIRST_EDGE_TILE + 48)

#define POWERCUT_TILE 48
#define RUBBLE_TILE 51

#define FIRST_BRUSH_TILE 240

#define NUM_TOOLBAR_BUTTONS 13

#define MAX_POPULATION_DENSITY 15

#define NUM_TERRAIN_TYPES 3

#define STARTING_TAX_RATE 7
#define STARTING_FUNDS 10000

#define FIRE_AND_POLICE_MAINTENANCE_COST 100
#define ROAD_MAINTENANCE_COST 10

#define POPULATION_MULTIPLIER 17

#define MIN_BUDGET_DISPLAY_TIME 16

#define BUILDING_MAX_FIRE_COUNTER 3

#define MIN_FRAMES_BETWEEN_DISASTER 2500
#define FRAMES_PER_YEAR (MAX_BUILDINGS * 12)
#define MIN_TIME_BETWEEN_DISASTERS (FRAMES_PER_YEAR * 2)
#define MAX_TIME_BETWEEN_DISASTERS (FRAMES_PER_YEAR * 6)

#define DISASTER_MESSAGE_DISPLAY_TIME 60


typedef enum BuildingType
{
	BuildingType_None = 0,
	Residential,
	Commercial,
	Industrial,
	Powerplant,
	Park,
	PoliceDept,
	FireDept,
	Stadium,
	Rubble3x3,
	Rubble4x4,
	Num_BuildingTypes = Stadium + 1
} BuildingType;

static inline bool IsRubble(uint8_t buildingType)
{
	return buildingType >= Rubble3x3;
}

typedef struct
{
	uint8_t x : 6;
	uint8_t y : 6;
	uint8_t type : 4;
	uint8_t populationDensity : 4;
	uint8_t onFire : 2;
	bool heavyTraffic : 1;
	bool hasPower : 1;
} Building;

typedef struct
{
	uint16_t cost;
	uint8_t width;
	uint8_t height;
	uint8_t drawTile;
} BuildingInfo;

static bool PlaceBuilding(uint8_t buildingType, uint8_t x, uint8_t y);
static bool CanPlaceBuilding(uint8_t buildingType, uint8_t x, uint8_t y);
static const BuildingInfo* GetBuildingInfo(uint8_t buildingType);
static Building* GetBuilding(uint8_t x, uint8_t y);
static void DestroyBuilding(Building* building);


// Connectivity refers to roads + power lines

enum ConnectivityMask
{
	RoadMask = 1,
	PowerlineMask = 2
};

static uint8_t GetConnections(int x, int y);
static void SetConnections(int x, int y, uint8_t newVal);
static void CalculatePowerConnectivity(void);
static int GetConnectivityTileVariant(int x, int y, uint8_t mask);
static bool IsSuitableForBridgedTile(int x, int y, uint8_t mask);
static uint8_t *GetPowerGrid(void);


static uint8_t GetTerrainTile(int x, int y);
static bool IsTerrainClear(int x, int y);

static const uint8_t* GetTerrainData(uint8_t index);




typedef struct
{
	uint16_t year;	// Starts at 1900
	uint8_t month;
	uint8_t simulationStep;

	int32_t money;

	// 2 bits per tile : road and power line
	uint8_t connectionMap[MAP_WIDTH * MAP_HEIGHT / 4];

	uint8_t terrainType;
	uint8_t taxRate;

	uint16_t residentialPopulation;
	uint16_t industrialPopulation;
	uint16_t commercialPopulation;

	int32_t taxesCollected;
	uint8_t policeBudget;
	uint8_t fireBudget;
	uint16_t roadBudget;

	uint16_t timeToNextDisaster;

	Building buildings[MAX_BUILDINGS];
} GameState;

extern GameState State;

static uint16_t GetRandFromSeed(uint16_t randVal);
static uint16_t GetRand(void);

static void InitGame(void);
static void TickGame(void);

void SaveCity(void);
static bool LoadCity(void);

static void FocusTile(uint8_t x, uint8_t y);





#define INPUT_LEFT 1
#define INPUT_RIGHT 2
#define INPUT_UP 4
#define INPUT_DOWN 8
#define INPUT_A 16
#define INPUT_B 32

enum BrushTypes
{
	Bulldozer,
	RoadBrush,
	PowerlineBrush,
	FirstBuildingBrush,
	LastBuildingBrush = FirstBuildingBrush + Num_BuildingTypes - 2
};

enum
{
	SaveLoadToolbarButton = LastBuildingBrush + 1,
	BudgetToolbarButton
};

enum
{
	StartScreen,
	NewCityMenu,
	InGame,
	InGameDisaster,
	ShowingToolbar,
	SaveLoadMenu,
	BudgetMenu
};

typedef struct
{
	int16_t scrollX, scrollY;		// Where on the map (in pixels) display is scrolled to
	uint8_t selectX, selectY;		// Which tile is selected
	uint8_t brush;					// What will be placed 
	uint8_t selection;      // For when toolbar is open or in a menu
	uint8_t state;    // Which state the game is in
	bool autoBudget : 1;
} UIStateStruct;

extern UIStateStruct UIState;




static void UpdateInterface(void);

static void GetBuildingBrushLocation(BuildingType buildingType, uint8_t* outX, uint8_t* outY);






static void PutPixel(int x, int y, uint8_t colour);
static void DrawFilledRect(uint8_t x, uint8_t y, uint8_t w, uint8_t h, uint8_t colour);
static void DrawRect(uint8_t x, uint8_t y, uint8_t w, uint8_t h, uint8_t colour);

static void Draw(void);

static void ResetVisibleTileCache(void);
static void RefreshBuildingTiles(Building* building);
static void RefreshTile(uint8_t x, uint8_t y);
static void RefreshTileAndConnectedNeighbours(uint8_t x, uint8_t y);

static void SetTile(uint8_t x, uint8_t y, uint8_t tile);



#define FONT_WIDTH 4
#define FONT_HEIGHT 6

static void DrawString(const char* str, uint8_t x, uint8_t y);
static void DrawInt(int32_t val, uint8_t x, uint8_t y);
static uint8_t DrawCurrency(int32_t val, uint8_t x, uint8_t y);



static const char* GetToolbarString(int index);
static const char* GetMonthString(int index);



static void Simulate(void);
static bool StartRandomFire(void);
#ifdef MICROCITY_COLOR
static uint8_t Framebuffer[DISPLAY_WIDTH * DISPLAY_HEIGHT / 2];
static fb_data ColorScanline[DISPLAY_WIDTH * DISPLAY_SCALE];
static void PutColorPixel(int x, int y, uint8_t index);
static void DrawColorBitmap(const uint8_t *bmp, int x, int y, int w, int h);
#else
static uint8_t Framebuffer[DISPLAY_WIDTH * DISPLAY_HEIGHT / 8];
#if DISPLAY_SCALE > 1
static uint8_t MonoScanline[DISPLAY_WIDTH * DISPLAY_SCALE];
#endif
#endif
static uint8_t PowerGrid[MAP_WIDTH * MAP_HEIGHT / 8];
static uint16_t PowerQueue[MAP_WIDTH * MAP_HEIGHT];
static bool HasCity;
static uint8_t PreviewTerrain;
static bool MenuRequest;
static uint16_t RandomState = 0xabc;

/* Amalgamated engine declarations. */
static uint16_t GetRandFromSeed(uint16_t randVal);
static uint16_t GetRand(void);
static void InitGame(void);
static void FocusTile(uint8_t x, uint8_t y);
static void TickGame(void);
static const uint8_t* GetTerrainData(uint8_t index);
static bool IsTerrainClear(int x, int y);
static uint8_t GetTerrainTile(int x, int y);
static const BuildingInfo* GetBuildingInfo(uint8_t buildingType);
static bool PlaceBuilding(uint8_t buildingType, uint8_t x, uint8_t y);
static bool CanPlaceBuilding(uint8_t buildingType, uint8_t x, uint8_t y);
static Building* GetBuilding(uint8_t x, uint8_t y);
static void DestroyBuilding(Building* building);
static uint8_t GetConnections(int x, int y);
static void SetConnections(int x, int y, uint8_t newVal);
static uint8_t GetNeighbouringConnectivity(int x, int y, uint8_t mask);
static bool IsSuitableForBridgedTile(int x, int y, uint8_t mask);
static int GetConnectivityTileVariant(int x, int y, uint8_t mask);
static void CalculatePowerConnectivity(void);
static void PowerFloodFill(uint8_t x, uint8_t y);
static uint8_t GetNumRoadConnections(Building* building);
static uint8_t GetManhattanDistance(Building* a, Building* b);
static void DoBudget(void);
static bool SpreadFire(Building* building);
static void SimulateBuilding(Building* building);
static void CountPopulation(void);
static void Simulate(void);
static bool StartRandomFire(void);
static void UpdateInterface(void);
static void GetBuildingBrushLocation(BuildingType buildingType, uint8_t* outX, uint8_t* outY);
static void HandleMovementInput(uint8_t input);
static void HandleInput(uint8_t input);
static const char* GetToolbarString(int index);
static const char* GetMonthString(int index);
static void DrawChar(char c);
static void DrawString(const char* str, uint8_t x, uint8_t y);
static void DrawInt(int32_t val, uint8_t x, uint8_t y);
static uint8_t DrawCurrency(int32_t val, uint8_t x, uint8_t y);
static const uint8_t* GetTileData(uint8_t tile);
static bool HasHighTraffic(int x, int y);
static uint8_t CalculateBuildingTile(Building* building, uint8_t x, uint8_t y);
static uint8_t CalculateTile(int x, int y);
static void ResetVisibleTileCache(void);
static void DrawTiles(void);
static void ScrollUp(int amount);
static void ScrollDown(int amount);
static void ScrollLeft(int amount);
static void ScrollRight(int amount);
static void DrawCursorRect(uint8_t cursorDrawX, uint8_t cursorDrawY, uint8_t cursorWidth, uint8_t cursorHeight);
static void DrawCursor(void);
static void AnimatePowercuts(void);
static void RefreshTile(uint8_t x, uint8_t y);
static void SetTile(uint8_t x, uint8_t y, uint8_t tile);
static void RefreshTileAndConnectedNeighbours(uint8_t x, uint8_t y);
static void RefreshBuildingTiles(Building* building);
static void DrawTileAt(uint8_t tile, int x, int y);
static void DrawFilledRect(uint8_t x, uint8_t y, uint8_t w, uint8_t h, uint8_t colour);
static void DrawRect(uint8_t x, uint8_t y, uint8_t w, uint8_t h, uint8_t colour);
static void DrawUI(void);
static void DrawInGame(void);
static void DrawBudgetMenu(void);
static void Draw(void);
static void PutPixel(int x, int y, uint8_t colour);
static bool LoadCity(void);


/* ---- Upstream Game (adapted) ---- */

GameState State;

static uint16_t GetRandFromSeed(uint16_t randVal)
{
	uint16_t lsb = randVal & 1;
	randVal >>= 1;
	if (lsb == 1)
		randVal ^= 0xB400u;

	return randVal;
}

static uint16_t GetRand(void)
{
	

	RandomState = GetRandFromSeed(RandomState);

	return RandomState - 1;
}

static void InitGame(void)
{
	uint8_t* ptr = (uint8_t*)(&State);
	for (size_t n = 0; n < sizeof(GameState); n++)
	{
		*ptr = 0;
		ptr++;
	}

	State.taxRate = STARTING_TAX_RATE;
	State.timeToNextDisaster = MAX_TIME_BETWEEN_DISASTERS;

	rb->memset(&UIState, 0, sizeof(UIState));
	RandomState = 0xabc;
	UIState.brush = RoadBrush; //FirstBuildingBrush + 1;
	FocusTile(MAP_WIDTH / 2, MAP_HEIGHT / 2);

	State.money = STARTING_FUNDS;
	UIState.autoBudget = true;
	ResetVisibleTileCache();
}

static void FocusTile(uint8_t x, uint8_t y)
{
	UIState.selectX = x;
	UIState.selectY = y;
	UIState.scrollX = UIState.selectX * 8 + TILE_SIZE / 2 - DISPLAY_WIDTH / 2;
	UIState.scrollY = UIState.selectY * 8 + TILE_SIZE / 2 - DISPLAY_HEIGHT / 2;
}

static void TickGame(void)
{
	if (UIState.state == InGame || UIState.state == ShowingToolbar)
	{
		Simulate();
	}
	if (UIState.state == InGameDisaster)
	{
		if (UIState.selection == 0)
		{
			UIState.state = InGame;
		}
		else UIState.selection--;
	}

	UpdateInterface();

	Draw();
}



/* ---- Upstream Terrain (adapted) ---- */

const uint8_t Terrain1Data[] PROGMEM =
{
// 48, 48
// 0
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x3f, 0x0f, 
0x07, 0x01, 0xc0, 0xe0, 0xf8, 0xfc, 0xfe, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xe0, 0xc0, 
0x80, 0x00, 0x03, 0x0f, 0x1f, 0x3f, 0x3f, 0x7f, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xfe, 0xfc, 0xf8, 0xf8, 0xf0, 0xe0, 
0xc0, 0x80, 0x01, 0x03, 0x07, 0x0f, 0x3f, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xfe, 0xf8, 0xe0, 0x00, 0x00, 0x00, 
0x03, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0x3f, 0x00, 0x00, 0x00, 
0x00, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0x3f, 0x0f, 0x07, 0x00, 0x00, 0x80, 0xc0, 0xf8, 
0xfe, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 

};
const uint8_t Terrain2Data[] PROGMEM =
{
// 48, 48
// 0
0x00, 0xf0, 0xf8, 0xfc, 0xfc, 0xfc, 0xfe, 0xfe, 
0xfe, 0xfc, 0xfc, 0xfc, 0xfc, 0xfc, 0xfc, 0xfe, 
0xfe, 0xfe, 0xfe, 0xfe, 0xfe, 0xfe, 0xfe, 0xfc, 
0xf8, 0xf8, 0xf8, 0xf8, 0xf8, 0xf8, 0xf8, 0xf8, 
0xfc, 0xfc, 0xfc, 0xfc, 0xfe, 0xfe, 0xfe, 0xfe, 
0xfe, 0xfe, 0xfe, 0xfe, 0xfc, 0xf8, 0xc0, 0x00, 
0x00, 0x00, 0x81, 0xc3, 0xe3, 0xe3, 0xe3, 0xe3, 
0xe3, 0xe3, 0xe3, 0xc7, 0x07, 0x0f, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x0f, 0x00, 
0x00, 0x00, 0x1f, 0x3f, 0x7f, 0x7f, 0x7f, 0x7f, 
0x3f, 0x3f, 0x3f, 0x0f, 0x80, 0xc0, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x1f, 0x0f, 
0x0f, 0x0f, 0x0f, 0x0f, 0x0f, 0x0f, 0x07, 0x07, 
0x07, 0x03, 0x03, 0x83, 0xc3, 0xc1, 0x80, 0x00, 
0x00, 0x00, 0x00, 0xc0, 0xf8, 0xfc, 0xfe, 0xfe, 
0xfe, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xfc, 
0xfc, 0xf8, 0xf8, 0xf8, 0xf8, 0xf8, 0xfc, 0xfe, 
0xfe, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x00, 
0x00, 0x00, 0x07, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0x07, 0x00, 0x00, 
0x00, 0x3c, 0x7f, 0x7f, 0x7f, 0x7f, 0x7f, 0x3f, 
0x3f, 0x3f, 0x3f, 0x3f, 0x3f, 0x3f, 0x3f, 0x3f, 
0x1f, 0x1f, 0x0f, 0x0f, 0x07, 0x07, 0x0f, 0x0f, 
0x0f, 0x0f, 0x3f, 0x3f, 0x7f, 0x7f, 0x3f, 0x3f, 
0x3f, 0x1f, 0x1f, 0x1f, 0x1f, 0x1f, 0x3f, 0x7f, 
0x7f, 0x7f, 0x7f, 0x7f, 0x3f, 0x1e, 0x00, 0x00, 

};
const uint8_t Terrain3Data[] PROGMEM =
{
// 48, 48
// 0
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0x1f, 0x00, 0x00, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x7f, 
0x7f, 0x7f, 0x3f, 0x3f, 0x3f, 0x7f, 0xff, 0xff, 
0xff, 0x7f, 0x7f, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xe0, 0x00, 0x00, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x80, 0x00, 
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
0x00, 0x00, 0x00, 0x00, 0x01, 0x03, 0x0f, 0x7f, 
0x7f, 0x7f, 0x7f, 0xff, 0xff, 0xff, 0xff, 0xff, 
0x7f, 0x7f, 0x3f, 0x3f, 0x3f, 0x1f, 0x00, 0x00, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xfe, 0xfe, 0xfc, 0xf8, 0xf0, 0x80, 0x00, 0x00, 
0x00, 0x00, 0x00, 0x00, 0x00, 0xe0, 0xf0, 0xf8, 
0xfc, 0xfc, 0xfc, 0xf8, 0xf8, 0xf8, 0xf8, 0xf8, 
0xf8, 0xfc, 0xfc, 0xfc, 0xf8, 0xf0, 0x00, 0x00, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0x1f, 0x03, 0x00, 0x00, 
0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x0f, 0x0f, 
0x1f, 0x3f, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0x00, 0x00, 0x00, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xfe, 0xfe, 0xfc, 
0xfc, 0xfc, 0xfc, 0xfc, 0xfc, 0xfc, 0xfc, 0xfc, 
0xfc, 0xfe, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0x1f, 0x00, 0x00, 

};


static const uint8_t* GetTerrainData(uint8_t index)
{
	switch (index)
	{
	default:
	case 0: return Terrain1Data;
	case 1: return Terrain2Data;
	case 2: return Terrain3Data;
	}

}

static bool IsTerrainClear(int x, int y)
{
	if (x < 0 || y < 0 || x >= MAP_WIDTH || y >= MAP_HEIGHT) return false;
	int blockX = x >> 3;
	int blockY = y >> 3;
	uint8_t blockU = x & 7;
	uint8_t blockV = y & 7;
	int index = (blockY * (MAP_WIDTH / 8) + blockX) * 8 + blockU;
	uint8_t mask = 1 << blockV;

	const uint8_t* terrainData = GetTerrainData(State.terrainType);

	uint8_t blockData = pgm_read_byte(&terrainData[index]);

	return (blockData & mask) != 0;
}

static uint8_t GetTerrainTile(int x, int y)
{
	bool northClear = y == 0 || IsTerrainClear(x, y - 1);
	bool eastClear = x >= MAP_WIDTH - 1 || IsTerrainClear(x + 1, y);
	bool southClear = y >= MAP_HEIGHT - 1 || IsTerrainClear(x, y + 1);
	bool westClear = x == 0 || IsTerrainClear(x - 1, y);

	if (IsTerrainClear(x, y))
	{
		if (!northClear && !westClear)
			return NORTH_WEST_EDGE_TILE;
		if (!northClear && !eastClear)
			return NORTH_EAST_EDGE_TILE;
		if (!southClear && !westClear)
			return SOUTH_WEST_EDGE_TILE;
		if (!southClear && !eastClear)
			return SOUTH_EAST_EDGE_TILE;

		return FIRST_TERRAIN_TILE + ((((y * 359)) ^ ((x * 431))) & 3);
	}
	else
	{
		return FIRST_WATER_TILE + ((((y * 359)) ^ ((x * 431))) & 3);
	}
}


/* ---- Upstream Building (adapted) ---- */

const BuildingInfo BuildingMetaData[] PROGMEM =
{
	// None,
	{ 0, 0, 0, 0 },
	// Residential,
	{ 100, 3, 3, 64 },
	// Commercial,
	{ 100, 3, 3, 67 },
	// Industrial,
	{ 100, 3, 3, 70 },
	// Powerplant,
	{ 3000, 4, 4, 160 },
	// Park,
	{ 50, 3, 3, 73 },
	// PoliceDept,
	{ 500, 3, 3, 76 },
	// FireDept,
	{ 500, 3, 3, 124 },
	// Stadium,
	{ 3000, 4, 4, 164 },
	// Rubble3x3,
	{ 0, 3, 3, 0 },
	// Rubble4x4,
	{ 0, 4, 4, 0 },
};

static const BuildingInfo* GetBuildingInfo(uint8_t buildingType)
{
	return &BuildingMetaData[buildingType];
}

static bool PlaceBuilding(uint8_t buildingType, uint8_t x, uint8_t y)
{
	int index = 0;

	while (index < MAX_BUILDINGS)
	{
		if (State.buildings[index].type == 0)
		{
			break;
		}
		index++;
	}

	if (index == MAX_BUILDINGS)
	{
		// Look for rubble placements and replace them instead:
		index = 0;

		while (index < MAX_BUILDINGS)
		{
			if (State.buildings[index].type == Rubble3x3 || State.buildings[index].type == Rubble4x4)
			{
				break;
			}
			index++;
		}

		if (index == MAX_BUILDINGS)
		{
			return false;
		}
	}

	Building* newBuilding = &State.buildings[index];
	newBuilding->type = buildingType;
	newBuilding->x = x;
	newBuilding->y = y;
	newBuilding->populationDensity = 0;
	newBuilding->hasPower = false;
	newBuilding->heavyTraffic = false;
	newBuilding->onFire = 0;

	// Internally building space is represented as power lines to correctly flood fill etc
	const BuildingInfo* metadata = GetBuildingInfo(buildingType);
	uint8_t width = pgm_read_byte(&metadata->width);
	uint8_t height = pgm_read_byte(&metadata->height);
	uint8_t connectionMask = buildingType == Park ? 0 : PowerlineMask;

	for (int i = x; i < x + width; i++)
	{
		for (int j = y; j < y + height; j++)
		{
			SetConnections(i, j, connectionMask);
		}
	}

	// Check for overlapping rubble and remove
	for (int n = 0; n < MAX_BUILDINGS; n++)
	{
		Building* building = &State.buildings[n];

		if (IsRubble(building->type))
		{
			const BuildingInfo* otherMetadata = GetBuildingInfo(building->type);
			uint8_t otherWidth = pgm_read_byte(&otherMetadata->width);
			uint8_t otherHeight = pgm_read_byte(&otherMetadata->height);

			if (x + width > building->x && x < building->x + otherWidth
				&& y + height > building->y && y < building->y + otherHeight)
			{
				building->type = 0;
			}
		}
	}

	RefreshBuildingTiles(newBuilding);

	return true;
}

static bool CanPlaceBuilding(uint8_t buildingType, uint8_t x, uint8_t y)
{
	const BuildingInfo* metadata = GetBuildingInfo(buildingType);
	uint8_t width = pgm_read_byte(&metadata->width);
	uint8_t height = pgm_read_byte(&metadata->height);

	if (x + width > MAP_WIDTH)
		return false;
	if (y + height > MAP_HEIGHT)
		return false;

	// Check if trying to build on top of road
	for (int i = x; i < x + width; i++)
	{
		for (int j = y; j < y + height; j++)
		{
			// Check terrain is not water
			if (IsTerrainClear(i, j) == false)
				return false;

			if (GetConnections(i, j) & RoadMask)
				return false;
		}
	}

	// Check building overlaps
	for (int n = 0; n < MAX_BUILDINGS; n++)
	{
		Building* building = &State.buildings[n];

		if (building->type && !IsRubble(building->type))
		{
			const BuildingInfo* otherMetadata = GetBuildingInfo(building->type);
			uint8_t otherWidth = pgm_read_byte(&otherMetadata->width);
			uint8_t otherHeight = pgm_read_byte(&otherMetadata->height);

			if (x + width > building->x && x < building->x + otherWidth
				&& y + height > building->y && y < building->y + otherHeight)
			{
				return false;
			}
		}

	}

	return true;
}

static Building* GetBuilding(uint8_t x, uint8_t y)
{
	for (int n = 0; n < MAX_BUILDINGS; n++)
	{
		Building* building = &State.buildings[n];

		if (building->type)
		{
			const BuildingInfo* metadata = GetBuildingInfo(building->type);
			uint8_t width = pgm_read_byte(&metadata->width);
			uint8_t height = pgm_read_byte(&metadata->height);

			if (x >= building->x && x < building->x + width && y >= building->y && y < building->y + height)
			{
				return building;
			}
		}
	}

	return NULL;
}

static void DestroyBuilding(Building* building)
{
	CountPopulation();
	if (building->type == Residential) State.residentialPopulation -= building->populationDensity;
	if (building->type == Industrial) State.industrialPopulation -= building->populationDensity;
	if (building->type == Commercial) State.commercialPopulation -= building->populationDensity;
	building->populationDensity = 0;
	const BuildingInfo* info = GetBuildingInfo(building->type);
	uint8_t width = pgm_read_byte(&info->width);
	uint8_t height = pgm_read_byte(&info->height);

	for (int y = building->y; y < building->y + height; y++)
	{
		for (int x = building->x; x < building->x + width; x++)
		{
			SetConnections(x, y, 0);
		}
	}

	building->onFire = 0;
	building->type = width == 3 ? Rubble3x3 : Rubble4x4;

	for (uint8_t y = building->y; y < building->y + height; y++)
	{
		for (uint8_t x = building->x; x < building->x + width; x++)
		{
			SetTile(x, y, RUBBLE_TILE);
		}
	}
}

/* ---- Upstream Connectivity (adapted) ---- */

static void PowerFloodFill(uint8_t x, uint8_t y);
static uint8_t *GetPowerGrid(void);

static uint8_t GetConnections(int x, int y)
{
	if (x >= 0 && x < MAP_WIDTH && y >= 0 && y < MAP_HEIGHT)
	{
		int index = y * MAP_WIDTH + x;
		uint8_t mapVal = State.connectionMap[index >> 2];
		int shift = 2 * (index & 3);
		return (mapVal >> shift) & 3;
	}

	return 0;
}

static void SetConnections(int x, int y, uint8_t newVal)
{
	if (x >= 0 && x < MAP_WIDTH && y >= 0 && y < MAP_HEIGHT)
	{
		int index = y * MAP_WIDTH + x;
		int shift = 2 * (index & 3);

		index >>= 2;
		uint8_t oldVal = State.connectionMap[index] & (~(3 << shift));
		State.connectionMap[index] = oldVal | (newVal << shift);
	}
}

const uint8_t TileVariants[] PROGMEM =
{
	0, 1, 0, 5, 1, 1, 2, 9, 0, 4, 0, 8, 3, 7, 6, 10
};

enum
{
	Neighbour_North = 1,
	Neighbour_East = 2,
	Neighbour_South = 4,
	Neighbour_West = 8
};

// Returns a 4 bit mask based on neighbouring connectivity
static uint8_t GetNeighbouringConnectivity(int x, int y, uint8_t mask)
{
	uint8_t neighbourMask = 0;

	if (y > 0 && (GetConnections(x, y - 1) & mask))
	{
		neighbourMask |= Neighbour_North;
	}
	if (x < MAP_WIDTH - 1 && (GetConnections(x + 1, y) & mask))
	{
		neighbourMask |= Neighbour_East;
	}
	if (y < MAP_HEIGHT - 1 && (GetConnections(x, y + 1) & mask))
	{
		neighbourMask |= Neighbour_South;
	}
	if (x > 0 && (GetConnections(x - 1, y) & mask))
	{
		neighbourMask |= Neighbour_West;
	}

	return neighbourMask;
}

static bool IsSuitableForBridgedTile(int x, int y, uint8_t mask)
{
	uint8_t neighbours = GetNeighbouringConnectivity(x, y, mask);
	
	if(neighbours == Neighbour_North || neighbours == Neighbour_East || neighbours == Neighbour_South || neighbours == Neighbour_West
	|| neighbours == (Neighbour_North | Neighbour_South) || neighbours == (Neighbour_East | Neighbour_West))
	{
		if(neighbours & Neighbour_North)
		{
			if(!IsTerrainClear(x, y - 1) && (GetNeighbouringConnectivity(x, y - 1, mask) & (Neighbour_East | Neighbour_West)))
				return false;
		}
		if(neighbours & Neighbour_East)
		{
			if(!IsTerrainClear(x + 1, y) && (GetNeighbouringConnectivity(x + 1, y, mask) & (Neighbour_North | Neighbour_South)))
				return false;
		}
		if(neighbours & Neighbour_South)
		{
			if(!IsTerrainClear(x, y + 1) && (GetNeighbouringConnectivity(x, y + 1, mask) & (Neighbour_East | Neighbour_West)))
				return false;
		}
		if(neighbours & Neighbour_West)
		{
			if(!IsTerrainClear(x - 1, y) && (GetNeighbouringConnectivity(x - 1, y, mask) & (Neighbour_North | Neighbour_South)))
				return false;
		}
		
		return true;
	}
	
	return false;
}

// Based on neighbouring tile types, get which visual tile to use
static int GetConnectivityTileVariant(int x, int y, uint8_t mask)
{
	uint8_t neighbours = GetNeighbouringConnectivity(x, y, mask);

	return pgm_read_byte(&TileVariants[neighbours]);
}

static inline bool IsTilePowered(uint8_t x, uint8_t y)
{
	int index = y * MAP_WIDTH + x;
	int mask = 1 << (index & 7);
	uint8_t val = GetPowerGrid()[index >> 3];

	return (val & mask) != 0;
}

static inline void SetTilePowered(uint8_t x, uint8_t y)
{
	int index = y * MAP_WIDTH + x;
	int mask = 1 << (index & 7);
	GetPowerGrid()[index >> 3] |= mask;
}

static void CalculatePowerConnectivity(void)
{
	// Clear power from grid
	for (int n = 0; n < MAP_WIDTH * MAP_HEIGHT / 8; n++)
	{
		GetPowerGrid()[n] = 0;
	}

	// Flood fill from power plants
	for (int n = 0; n < MAX_BUILDINGS; n++)
	{
		if (State.buildings[n].type == Powerplant)
		{
			PowerFloodFill(State.buildings[n].x, State.buildings[n].y);
		}
	}

	// Set powered flags on buildings
	for (int n = 0; n < MAX_BUILDINGS; n++)
	{
		if (State.buildings[n].type)
		{
			State.buildings[n].hasPower = IsTilePowered(State.buildings[n].x, State.buildings[n].y);
		}
	}
}


/* Each cell is marked on enqueue, so at most MAP_WIDTH*MAP_HEIGHT entries.
 * Unlike the AVR scratch-buffer stack this has a proven, explicit bound. */
static void PowerFloodFill(uint8_t x, uint8_t y)
{
    unsigned head = 0, tail = 0;
    if (!(GetConnections(x, y) & PowerlineMask) || IsTilePowered(x, y)) return;
    SetTilePowered(x, y);
    PowerQueue[tail++] = y * MAP_WIDTH + x;
    while (head < tail)
    {
        unsigned cell = PowerQueue[head++];
        int px = cell % MAP_WIDTH, py = cell / MAP_WIDTH;
        static const int8_t dx[4] = {-1, 1, 0, 0};
        static const int8_t dy[4] = {0, 0, -1, 1};
        for (int d = 0; d < 4; ++d)
        {
            int nx = px + dx[d], ny = py + dy[d];
            if ((GetConnections(nx, ny) & PowerlineMask) && !IsTilePowered(nx, ny))
            {
                SetTilePowered(nx, ny);
                PowerQueue[tail++] = ny * MAP_WIDTH + nx;
            }
        }
    }
}


/* ---- Upstream Simulation (adapted) ---- */

enum SimulationSteps
{
	SimulateBuildings = 0,
	SimulatePower = MAX_BUILDINGS,
	SimulatePopulation,
	SimulateNextMonth
};

#define DebugBuildingScore(...) ((void)0)

#define SIM_INCREMENT_POP_THRESHOLD 20				// Score must be more than this to grow
#define SIM_DECREMENT_POP_THRESHOLD -30				// Score must be less than this to shrink

#define AVERAGE_POPULATION_DENSITY 8
#define SIM_BASE_SCORE 15							// When population is zero
#define SIM_AVERAGING_STRENGTH 0
#define SIM_EMPLOYMENT_BOOST 10
#define SIM_UNEMPLOYMENT_PENALTY 100
#define SIM_INDUSTRIAL_OPPORTUNITY_BOOST 10
#define SIM_COMMERCIAL_OPPORTUNITY_BOOST 10
#define SIM_LOCAL_BUILDING_DISTANCE 32
#define SIM_LOCAL_BUILDING_INFLUENCE 4
#define SIM_STADIUM_BOOST 100
#define SIM_PARK_BOOST 5
#define SIM_MAX_CRIME 50
#define SIM_RANDOM_STRENGTH_MASK 31
#define SIM_POLLUTION_INFLUENCE 2
#define SIM_MAX_POLLUTION 50
#define SIM_INDUSTRIAL_BASE_POLLUTION 8
#define SIM_TRAFFIC_BASE_POLLUTION 8
#define SIM_POWERPLANT_BASE_POLLUTION 32
#define SIM_HEAVY_TRAFFIC_THRESHOLD 12
#define SIM_IDEAL_TAX_RATE 6
#define SIM_TAX_RATE_PENALTY 10
#define SIM_FIRE_SPREAD_CHANCE 64					// If 8 bit rand value is less than this then attempt to spread fire
#define SIM_FIRE_BURN_CHANCE 64						// If 8 bit rand value is less than this then increase fire counter
#define SIM_FIRE_DEPT_BASE_INFLUENCE 64				// Higher means less influence
#define SIM_FIRE_DEPT_INFLUENCE_MULTIPLIER 5		// Higher means less influence (based on distance)

static uint8_t GetNumRoadConnections(Building* building)
{
	const BuildingInfo* info = GetBuildingInfo(building->type);
	uint8_t width = pgm_read_byte(&info->width);
	uint8_t height = pgm_read_byte(&info->height);
	uint8_t count = 0;

	if(building->y > 0)
	{
		for(uint8_t i = 0; i < width; i++)
		{
			if(GetConnections(building->x + i, building->y - 1) & RoadMask)
			{
				count++;
			}
		}
	}
	if(building->y + height < MAP_HEIGHT)
	{
		for(uint8_t i = 0; i < width; i++)
		{
			if(GetConnections(building->x + i, building->y + height) & RoadMask)
			{
				count++;
			}
		}
	}
	if(building->x > 0)
	{
		for(uint8_t i = 0; i < height; i++)
		{
			if(GetConnections(building->x - 1, building->y + i) & RoadMask)
			{
				count++;
			}
		}
	}
	if(building->x + width < MAP_WIDTH)
	{
		for(uint8_t i = 0; i < height; i++)
		{
			if(GetConnections(building->x + width, building->y + i) & RoadMask)
			{
				count++;
			}
		}
	}
		
	return count;
}

static uint8_t GetManhattanDistance(Building* a, Building* b)
{
	uint8_t x = a->x > b->x ? a->x - b->x : b->x - a->x;
	uint8_t y = a->y > b->y ? a->y - b->y : b->y - a->y;
	return x + y;
}

static void DoBudget(void)
{
	// Collect taxes
	int32_t totalPopulation = (State.residentialPopulation + State.commercialPopulation + State.industrialPopulation) * POPULATION_MULTIPLIER;
	State.taxesCollected = (totalPopulation * State.taxRate) / 100;

	State.money += State.taxesCollected;

	// Count police and fire departments for costing
	uint8_t numPoliceDept = 0;
	uint8_t numFireDept = 0;

	for (int n = 0; n < MAX_BUILDINGS; n++)
	{
		if (State.buildings[n].type == PoliceDept)
		{
			numPoliceDept++;
		}
		else if (State.buildings[n].type == FireDept)
		{
			numFireDept++;
		}
	}

	State.fireBudget = numFireDept;
	State.policeBudget = numPoliceDept;

	State.money -= FIRE_AND_POLICE_MAINTENANCE_COST * numFireDept;
	State.money -= FIRE_AND_POLICE_MAINTENANCE_COST * numPoliceDept;

	// Count road tiles for cost of road maintenance
	int numRoadTiles = 0;
	for (int y = 0; y < MAP_HEIGHT; y++)
	{
		for (int x = 0; x < MAP_WIDTH; x++)
		{
			if (GetConnections(x, y) & RoadMask)
				numRoadTiles++;
		}
	}

	State.roadBudget = (numRoadTiles * ROAD_MAINTENANCE_COST) / 100;
	State.money -= State.roadBudget;



	int32_t cashFlow = State.taxesCollected - State.roadBudget - State.policeBudget * FIRE_AND_POLICE_MAINTENANCE_COST - State.fireBudget * FIRE_AND_POLICE_MAINTENANCE_COST;
	if (!UIState.autoBudget || cashFlow <= 0 || State.money <= 0)
	{
		UIState.state = BudgetMenu;
		UIState.selection = 0;
	}
}

static bool SpreadFire(Building* building)
{
	const BuildingInfo* info = GetBuildingInfo(building->type);
	uint8_t width = pgm_read_byte(&info->width);
	uint8_t height = pgm_read_byte(&info->height);
	uint8_t x1 = building->x > 1 ? building->x - 2 : building->x;
	uint8_t y1 = building->y > 1 ? building->y - 2 : building->y;
	uint8_t x2 = building->x + width + 2;
	uint8_t y2 = building->y + height + 2;
	uint8_t spreadDirection = GetRand() & 3;

	if (spreadDirection & 1)
	{
		for (uint8_t j = building->y; j < building->y + height; j++)
		{
			Building* neighbour = GetBuilding(spreadDirection & 2 ? x1 : x2, j);

			if (neighbour && !neighbour->onFire && neighbour->type != Park && !IsRubble(neighbour->type))
			{
				neighbour->onFire = 1;
				RefreshBuildingTiles(neighbour);
				return true;
			}
		}
	}
	else
	{
		for (uint8_t i = building->x; i < building->x + width; i++)
		{
			Building* neighbour = GetBuilding(i, spreadDirection & 2 ? y1 : y2);

			if (neighbour && !neighbour->onFire && neighbour->type != Park && !IsRubble(neighbour->type))
			{
				neighbour->onFire = 1;
				RefreshBuildingTiles(neighbour);
				return true;
			}
		}
	}

	return false;
}

static void SimulateBuilding(Building* building)
{
	int8_t populationDensityChange = 0;

	if (building->onFire)
	{
		if (IsRubble(building->type))
		{
			building->onFire--;
			if ((GetRand() & 0xff) > SIM_FIRE_SPREAD_CHANCE)
			{
				SpreadFire(building);
			}
			RefreshBuildingTiles(building);
			return;
		}

		// Find closest fire department
		uint8_t closestFireDept = 0xff;

		for (int n = 0; n < MAX_BUILDINGS; n++)
		{
			Building* otherBuilding = &State.buildings[n];

			if (otherBuilding->type == FireDept && otherBuilding->hasPower)
			{
				uint8_t distance = GetManhattanDistance(building, otherBuilding);

				if (distance < closestFireDept)
				{
					closestFireDept = distance;
				}
			}
		}

		int fireDeptInfluence = SIM_FIRE_DEPT_BASE_INFLUENCE + closestFireDept * SIM_FIRE_DEPT_INFLUENCE_MULTIPLIER;
		
		if (fireDeptInfluence <= 255 && (GetRand() & 0xff) > (uint8_t)(fireDeptInfluence))
		{
			building->onFire--;
		}
		else if ((GetRand() & 0xff) > SIM_FIRE_SPREAD_CHANCE || !SpreadFire(building))
		{
			if ((GetRand() & 0xff) < SIM_FIRE_BURN_CHANCE)
			{
				if (building->onFire >= BUILDING_MAX_FIRE_COUNTER)
				{
					DestroyBuilding(building);
					building->onFire = BUILDING_MAX_FIRE_COUNTER;
				}
				else
				{
					building->onFire++;
				}
			}
		}
		building->heavyTraffic = false;
	}
	else if (building->type == Residential || building->type == Commercial || building->type == Industrial)
	{
		if (building->hasPower)
		{
			int score = 0;
			
			// random effect
			int randomEffect = (GetRand() & SIM_RANDOM_STRENGTH_MASK) - (SIM_RANDOM_STRENGTH_MASK / 2);
			score += randomEffect;
			
			// tend towards average population density
			score += (AVERAGE_POPULATION_DENSITY - building->populationDensity) * SIM_AVERAGING_STRENGTH;
			
			// tax rate effect
			score -= (State.taxRate - SIM_IDEAL_TAX_RATE) * SIM_TAX_RATE_PENALTY;

			// general population effect
			int populationEffect = 0;
			switch(building->type)
			{
				case Residential:
				if(State.residentialPopulation < State.industrialPopulation)
				{
					populationEffect += SIM_EMPLOYMENT_BOOST;
				}
				else if(State.residentialPopulation > State.industrialPopulation + State.commercialPopulation)
				{
					populationEffect -= SIM_UNEMPLOYMENT_PENALTY;
				}
				break;
				case Industrial:
				if(State.industrialPopulation < State.residentialPopulation || State.industrialPopulation < State.commercialPopulation)
				{
					populationEffect += SIM_INDUSTRIAL_OPPORTUNITY_BOOST;
				}
				break;
				case Commercial:
				if(State.commercialPopulation < State.residentialPopulation || State.commercialPopulation < State.industrialPopulation)
				{
					populationEffect += SIM_COMMERCIAL_OPPORTUNITY_BOOST;
				}
				break;
			}
			score += populationEffect;
			
			// If at least 3 road tiles are adjacent then assume that it is connected to the road network
			bool isRoadConnected = GetNumRoadConnections(building) >= 3;
			
			uint8_t closestPoliceStationDistance = 24;
			int16_t pollution = 0;
			int16_t localInfluence = 0;
			
			// influence from local buildings
			if(isRoadConnected)
			{
				if (building->populationDensity == 0)
				{
					score += SIM_BASE_SCORE;
				}

				for(int n = 0; n < MAX_BUILDINGS; n++)
				{
					Building* otherBuilding = &State.buildings[n];
					
					if(building != otherBuilding && otherBuilding->type && (otherBuilding->hasPower || otherBuilding->type == Park) && !otherBuilding->onFire)
					{
						uint8_t distance = GetManhattanDistance(building, otherBuilding);
						
						if(otherBuilding->type == PoliceDept && distance < closestPoliceStationDistance)
						{
							closestPoliceStationDistance = distance;
						}
						
						int buildingPollution = 0;
						
						if(otherBuilding->type == Industrial)
						{
							buildingPollution = SIM_INDUSTRIAL_BASE_POLLUTION + otherBuilding->populationDensity - distance;
						}
						else if(otherBuilding->type == Powerplant)
						{
							buildingPollution = SIM_POWERPLANT_BASE_POLLUTION - distance;
						}
						else if(otherBuilding->heavyTraffic)
						{
							buildingPollution = SIM_TRAFFIC_BASE_POLLUTION - distance;
						}
						
						if(buildingPollution > 0)
							pollution += buildingPollution;
						
						if(distance <= SIM_LOCAL_BUILDING_DISTANCE && GetNumRoadConnections(otherBuilding) >= 3)
						{
							switch(otherBuilding->type)
							{
								case Industrial:
								if(otherBuilding->populationDensity >= building->populationDensity && building->type == Residential)
								{
									localInfluence += SIM_LOCAL_BUILDING_INFLUENCE;
								}
								else if (otherBuilding->populationDensity > building->populationDensity && building->type == Commercial)
								{
									localInfluence += SIM_LOCAL_BUILDING_INFLUENCE;
								}
								break;
								case Residential:
								if(otherBuilding->populationDensity > building->populationDensity && (building->type == Commercial || building->type == Industrial))
								{
									localInfluence += SIM_LOCAL_BUILDING_INFLUENCE;
								}
								break;
								case Commercial:
								if(otherBuilding->populationDensity >= building->populationDensity && building->type == Residential)
								{
									localInfluence += SIM_LOCAL_BUILDING_INFLUENCE;
								}
								break;
								case Stadium:
								if(building->type == Residential || building->type == Commercial)
								{
									localInfluence += SIM_STADIUM_BOOST;
								}
								break;
								case Park:
								if(building->type == Residential)
								{
									localInfluence += SIM_PARK_BOOST;
								}
								break;
								default:
								break;
							}
						}
					}
				}
			}

			score += localInfluence;
			
			// negative effect from pollution
			if (building->type == Residential)
			{
				if (pollution > SIM_MAX_POLLUTION)
					pollution = SIM_MAX_POLLUTION;
				score -= pollution * SIM_POLLUTION_INFLUENCE;

			}
			
			// simulate crime based on how far the closest police station is and how populated the area is
			int crime = (building->populationDensity * (closestPoliceStationDistance - 16));
			if(crime > SIM_MAX_CRIME)
			{
				crime = SIM_MAX_CRIME;
			}
			else if (crime < 0)
			{
				crime = 0;
			}

			score -= crime;

			DebugBuildingScore(building, score, crime, pollution * SIM_POLLUTION_INFLUENCE, localInfluence, populationEffect, randomEffect);
			
			// increase or decrease population density based on score
			if (building->populationDensity < MAX_POPULATION_DENSITY && score >= SIM_INCREMENT_POP_THRESHOLD)
			{
				populationDensityChange = 1;
			}
			else if(building->populationDensity > 0 && score <= SIM_DECREMENT_POP_THRESHOLD)
			{
				populationDensityChange = -1;
			}
			
			building->heavyTraffic = building->populationDensity > SIM_HEAVY_TRAFFIC_THRESHOLD;
		}
		else
		{
			building->heavyTraffic = false;
			if (building->populationDensity > 0)
			{
				populationDensityChange = -1;
			}
		}
	}

	building->populationDensity += populationDensityChange;
	switch (building->type)
	{
	case Residential:
		State.residentialPopulation += populationDensityChange;
		break;
	case Industrial:
		State.industrialPopulation += populationDensityChange;
		break;
	case Commercial:
		State.commercialPopulation += populationDensityChange;
		break;
	}

	RefreshBuildingTiles(building);
}

static void CountPopulation(void)
{
	State.residentialPopulation = State.industrialPopulation = State.commercialPopulation = 0;

	for (int n = 0; n < MAX_BUILDINGS; n++)
	{
		switch (State.buildings[n].type)
		{
		case Residential:
			State.residentialPopulation += State.buildings[n].populationDensity;
			break;
		case Industrial:
			State.industrialPopulation += State.buildings[n].populationDensity;
			break;
		case Commercial:
			State.commercialPopulation += State.buildings[n].populationDensity;
			break;
		default:
			break;
		}
	}
}

static void Simulate(void)
{
	if (State.simulationStep < MAX_BUILDINGS)
	{
		SimulateBuilding(&State.buildings[State.simulationStep]);
	}
	else switch (State.simulationStep)
	{
	case SimulatePower:
		CalculatePowerConnectivity();
		break;
	case SimulatePopulation:
		CountPopulation();
		break;
	case SimulateNextMonth:
	{
		State.simulationStep = 0;
		State.month++;
		if (State.month >= 12)
		{
			State.month = 0;
			State.year++;

			DoBudget();
		}
	}
	return;
	}

	State.simulationStep++;
	State.timeToNextDisaster--;

	if (State.timeToNextDisaster == 0)
	{
		StartRandomFire();
		State.timeToNextDisaster = (GetRand() % (MAX_TIME_BETWEEN_DISASTERS - MIN_TIME_BETWEEN_DISASTERS)) + MIN_TIME_BETWEEN_DISASTERS;
	}
}

static bool StartRandomFire(void)
{
	int attemptsLeft = MAX_BUILDINGS;

	while (attemptsLeft)
	{
		int index = GetRand() & 0xff;
		if (index < MAX_BUILDINGS && State.buildings[index].type && !State.buildings[index].onFire && !IsRubble(State.buildings[index].type) && State.buildings[index].type != Park)
		{
			State.buildings[index].onFire = 1;
			RefreshBuildingTiles(&State.buildings[index]);
			FocusTile(State.buildings[index].x + 1, State.buildings[index].y + 1);

			UIState.state = InGameDisaster;
			UIState.selection = DISASTER_MESSAGE_DISPLAY_TIME;
			return true;
		}
		attemptsLeft--;
	}

	return false;
}


/* ---- Upstream Interface (adapted) ---- */

UIStateStruct UIState;




static void UpdateInterface(void)
{
	// Scroll screen to center the selected tile
	int targetX = UIState.selectX * 8 + TILE_SIZE / 2 - DISPLAY_WIDTH / 2;
	int targetY = UIState.selectY * 8 + TILE_SIZE / 2 - DISPLAY_HEIGHT / 2;

	int diffX = targetX - UIState.scrollX;
	UIState.scrollX = targetX - (diffX / 2);
	int diffY = targetY - UIState.scrollY;
	UIState.scrollY = targetY - (diffY / 2);

	/*if(UIState.scrollX < targetX)
	UIState.scrollX ++;
	else if(UIState.scrollX > targetX)
	UIState.scrollX --;
	if(UIState.scrollY < targetY)
	UIState.scrollY++;
	else if(UIState.scrollY > targetY)
	UIState.scrollY --;*/
}

static void GetBuildingBrushLocation(BuildingType buildingType, uint8_t* outX, uint8_t* outY)
{
	const BuildingInfo* buildingInfo = GetBuildingInfo(buildingType);
	uint8_t width = pgm_read_byte(&buildingInfo->width);
	uint8_t height = pgm_read_byte(&buildingInfo->height);

	if (UIState.selectX > 0)
	{
		if (UIState.selectX - 1 > MAP_WIDTH - width)
		{
			*outX = MAP_WIDTH - width;
		}
		else
		{
			*outX = UIState.selectX - 1;
		}
	}
	else
	{
		*outX = 0;
	}

	if (UIState.selectY > 0)
	{
		if (UIState.selectY - 1 > MAP_HEIGHT - height)
		{
			*outY = MAP_HEIGHT - height;
		}
		else
		{
			*outY = UIState.selectY - 1;
		}
	}
	else
	{
		*outY = 0;
	}
}

static void HandleMovementInput(uint8_t input)
{
	if ((input & INPUT_LEFT) && UIState.selectX > 0)
	{
		UIState.selectX--;
	}
	if ((input & INPUT_UP) && UIState.selectY > 0)
	{
		UIState.selectY--;
	}
	if ((input & INPUT_RIGHT) && UIState.selectX < MAP_WIDTH - 1)
	{
		UIState.selectX++;
	}
	if ((input & INPUT_DOWN) && UIState.selectY < MAP_HEIGHT - 1)
	{
		UIState.selectY++;
	}
}

static void HandleInput(uint8_t input)
{
	if (UIState.state == ShowingToolbar)
	{
		if (input & INPUT_LEFT)
		{
			if (UIState.selection == 0)
			{
				UIState.selection = NUM_TOOLBAR_BUTTONS - 1;
			}
			else UIState.selection--;
		}
		if (input & INPUT_RIGHT)
		{
			if (UIState.selection == NUM_TOOLBAR_BUTTONS - 1)
			{
				UIState.selection = 0;
			}
			else UIState.selection++;
		}
		if (input & (INPUT_A | INPUT_B))
		{
			if (UIState.selection <= LastBuildingBrush)
			{
				UIState.brush = UIState.selection;
				UIState.state = InGame;
			}
			else if (UIState.selection == SaveLoadToolbarButton)
			{
				UIState.state = InGame;
				MenuRequest = true;
			}
			else if (UIState.selection == BudgetToolbarButton)
			{
				UIState.state = BudgetMenu;
				UIState.selection = MIN_BUDGET_DISPLAY_TIME;
			}
		}
	}
	else if (UIState.state == InGameDisaster)
	{
		HandleMovementInput(input);
	}
	else if (UIState.state == InGame)
	{
		HandleMovementInput(input);

		if (input & INPUT_A)
		{
			UIState.state = ShowingToolbar;
			UIState.selection = UIState.brush;
		}

		if (input & INPUT_B)
		{
			if (UIState.brush == Bulldozer)
			{
				Building* building = GetBuilding(UIState.selectX, UIState.selectY);
				if (building && !IsRubble(building->type))
				{
					const BuildingInfo* buildingInfo = GetBuildingInfo(building->type);
					uint8_t width = pgm_read_byte(&buildingInfo->width);
					uint8_t height = pgm_read_byte(&buildingInfo->height);
					int cost = width * height * BULLDOZER_COST;

					if (State.money >= cost)
					{
						State.money -= cost;

						DestroyBuilding(building);
					}
					else
					{
						// TODO: not enough cash
					}
				}
				else
				{
					if (GetConnections(UIState.selectX, UIState.selectY))
					{
						if (State.money >= BULLDOZER_COST)
						{
							State.money -= BULLDOZER_COST;

							SetConnections(UIState.selectX, UIState.selectY, 0);
							RefreshTileAndConnectedNeighbours(UIState.selectX, UIState.selectY);
							SetTile(UIState.selectX, UIState.selectY, RUBBLE_TILE);
						}
						else
						{
							// TODO: not enough cash
						}
					}
					else
					{
						// TODO: nothing to bulldoze
					}
				}
			}
			else if (UIState.brush < FirstBuildingBrush)
			{
				// Is powerline or road

				Building* building = GetBuilding(UIState.selectX, UIState.selectY);
				if (building && !IsRubble(building->type))
				{
					// TODO: can't build here
				}
				else
				{
					int cost = UIState.brush == RoadBrush ? ROAD_COST : POWERLINE_COST;
					uint8_t mask = UIState.brush == RoadBrush ? RoadMask : PowerlineMask;
					uint8_t currentConnections = GetConnections(UIState.selectX, UIState.selectY);
					bool onGround =  IsTerrainClear(UIState.selectX, UIState.selectY);
					
					if(onGround || (currentConnections == 0 && IsSuitableForBridgedTile(UIState.selectX, UIState.selectY, mask)))
					{
						if ((currentConnections & mask) == 0)
						{
							if (State.money >= cost)
							{
								State.money -= cost;
								SetConnections(UIState.selectX, UIState.selectY, currentConnections | mask);

								// Remove rubble
								if (building)
								{
									building->type = 0;
								}

								RefreshTileAndConnectedNeighbours(UIState.selectX, UIState.selectY);
							}
							else
							{
								// TODO: not enough cash
							}
						}
					}
				}
			}
			else
			{
				// Is building placement
				BuildingType buildingType = (BuildingType)(UIState.brush - FirstBuildingBrush + 1);
				const BuildingInfo* buildingInfo = GetBuildingInfo(buildingType);
				uint8_t placeX, placeY;
				GetBuildingBrushLocation(buildingType, &placeX, &placeY);
				uint16_t cost = pgm_read_word(&buildingInfo->cost);

				if (CanPlaceBuilding(buildingType, placeX, placeY))
				{
					if (State.money >= cost)
					{
						if (PlaceBuilding(buildingType, placeX, placeY))
						{
							State.money -= cost;
						}
						else
						{
							// too many buildings
						}
					}
					else
					{
						// TODO: not enough cash
					}
				}
				else
				{
					// TODO: cannot place here, e.g. obstructed
				}
			}
		}
	}
	else if (UIState.state == BudgetMenu)
	{
		// Display for a minimum of a few frames to prevent closing the budget menu by accident
		if (UIState.selection >= MIN_BUDGET_DISPLAY_TIME)
		{
			if ((input & INPUT_LEFT) && State.taxRate > 0)
			{
				State.taxRate--;
			}
			if ((input & INPUT_RIGHT) && State.taxRate < 99)
			{
				State.taxRate++;
			}
			if (input & (INPUT_A | INPUT_B))
			{
				UIState.state = InGame;
			}
		}
	}
}



/* ---- Upstream Strings (adapted) ---- */

const char BulldozerStr[] PROGMEM = "Bulldozer";
const char RoadStr[] PROGMEM = "Road";
const char PowerlineStr[] PROGMEM = "Powerline";
const char ResidentialStr[] PROGMEM = "Residential";
const char CommericalStr[] PROGMEM = "Commercial";
const char IndustrialStr[] PROGMEM = "Industrial";
const char PowerplantStr[] PROGMEM = "Powerplant";
const char ParkStr[] PROGMEM = "Park";
const char PoliceDeptStr[] PROGMEM = "Police Dept";
const char FireDeptStr[] PROGMEM = "Fire Dept";
const char StadiumStr[] PROGMEM = "Stadium";
const char SaveLoadStr[] PROGMEM = "Save/Load";
const char BudgetStr[] PROGMEM = "Budget";

const char* const ToolbarStrings[] PROGMEM =
{
	BulldozerStr,
	RoadStr,
	PowerlineStr,
	ResidentialStr,
	CommericalStr,
	IndustrialStr,
	PowerplantStr,
	ParkStr,
	PoliceDeptStr,
	FireDeptStr,
	StadiumStr,
	SaveLoadStr,
	BudgetStr,
};

static const char* GetToolbarString(int index)
{
	return (const char*)pgm_read_ptr(&ToolbarStrings[index]);
}

const char JanStr[] PROGMEM = "Jan";
const char FebStr[] PROGMEM = "Feb";
const char MarStr[] PROGMEM = "Mar";
const char AprStr[] PROGMEM = "Apr";
const char MayStr[] PROGMEM = "May";
const char JunStr[] PROGMEM = "Jun";
const char JulStr[] PROGMEM = "Jul";
const char AugStr[] PROGMEM = "Aug";
const char SepStr[] PROGMEM = "Sep";
const char OctStr[] PROGMEM = "Oct";
const char NovStr[] PROGMEM = "Nov";
const char DecStr[] PROGMEM = "Dec";

const char* const MonthStrings[] PROGMEM =
{
	JanStr,
	FebStr,
	MarStr,
	AprStr,
	MayStr,
	JunStr,
	JulStr,
	AugStr,
	SepStr,
	OctStr,
	NovStr,
	DecStr
};

static const char* GetMonthString(int index)
{
	return (const char*)pgm_read_ptr(&MonthStrings[index]);
}




/* ---- Upstream Font (adapted) ---- */
// Compact font taken from
// https://hackaday.io/project/6309-vga-graphics-over-spi-and-serial-vgatonic/log/20759-a-tiny-4x6-pixel-font-that-will-fit-on-almost-any-microcontroller-license-mit


// Font Definition
const uint8_t font4x6[96][2] PROGMEM = {
	{ 0x00  ,  0x00 },   /*SPACE*/
	{ 0x49  ,  0x08 },   /*'!'*/
	{ 0xb4  ,  0x00 },   /*'"'*/
	{ 0xbe  ,  0xf6 },   /*'#'*/
	{ 0x7b  ,  0x7a },   /*'$'*/
	{ 0xa5  ,  0x94 },   /*'%'*/
	{ 0x55  ,  0xb8 },   /*'&'*/
	{ 0x48  ,  0x00 },   /*'''*/
	{ 0x29  ,  0x44 },   /*'('*/
	{ 0x44  ,  0x2a },   /*')'*/
	{ 0x15  ,  0xa0 },   /*'*'*/
	{ 0x0b  ,  0x42 },   /*'+'*/
	{ 0x00  ,  0x50 },   /*','*/
	{ 0x03  ,  0x02 },   /*'-'*/
	{ 0x00  ,  0x08 },   /*'.'*/
	{ 0x25  ,  0x90 },   /*'/'*/
	{ 0x76  ,  0xba },   /*'0'*/
	{ 0x59  ,  0x5c },   /*'1'*/
	{ 0xc5  ,  0x9e },   /*'2'*/
	{ 0xc5  ,  0x38 },   /*'3'*/
	{ 0x92  ,  0xe6 },   /*'4'*/
	{ 0xf3  ,  0x3a },   /*'5'*/
	{ 0x73  ,  0xba },   /*'6'*/
	{ 0xe5  ,  0x90 },   /*'7'*/
	{ 0x77  ,  0xba },   /*'8'*/
	{ 0x77  ,  0x3a },   /*'9'*/
	{ 0x08  ,  0x40 },   /*':'*/
	{ 0x08  ,  0x50 },   /*';'*/
	{ 0x2a  ,  0x44 },   /*'<'*/
	{ 0x1c  ,  0xe0 },   /*'='*/
	{ 0x88  ,  0x52 },   /*'>'*/
	{ 0xe5  ,  0x08 },   /*'?'*/
	{ 0x56  ,  0x8e },   /*'@'*/
	{ 0x77  ,  0xb6 },   /*'A'*/
	{ 0x77  ,  0xb8 },   /*'B'*/
	{ 0x72  ,  0x8c },   /*'C'*/
	{ 0xd6  ,  0xba },   /*'D'*/
	{ 0x73  ,  0x9e },   /*'E'*/
	{ 0x73  ,  0x92 },   /*'F'*/
	{ 0x72  ,  0xae },   /*'G'*/
	{ 0xb7  ,  0xb6 },   /*'H'*/
	{ 0xe9  ,  0x5c },   /*'I'*/
	{ 0x64  ,  0xaa },   /*'J'*/
	{ 0xb7  ,  0xb4 },   /*'K'*/
	{ 0x92  ,  0x9c },   /*'L'*/
	{ 0xbe  ,  0xb6 },   /*'M'*/
	{ 0xd6  ,  0xb6 },   /*'N'*/
	{ 0x56  ,  0xaa },   /*'O'*/
	{ 0xd7  ,  0x92 },   /*'P'*/
	{ 0x76  ,  0xee },   /*'Q'*/
	{ 0x77  ,  0xb4 },   /*'R'*/
	{ 0x71  ,  0x38 },   /*'S'*/
	{ 0xe9  ,  0x48 },   /*'T'*/
	{ 0xb6  ,  0xae },   /*'U'*/
	{ 0xb6  ,  0xaa },   /*'V'*/
	{ 0xb6  ,  0xf6 },   /*'W'*/
	{ 0xb5  ,  0xb4 },   /*'X'*/
	{ 0xb5  ,  0x48 },   /*'Y'*/
	{ 0xe5  ,  0x9c },   /*'Z'*/
	{ 0x69  ,  0x4c },   /*'['*/
	{ 0x91  ,  0x24 },   /*'\'*/
	{ 0x64  ,  0x2e },   /*']'*/
	{ 0x54  ,  0x00 },   /*'^'*/
	{ 0x00  ,  0x1c },   /*'_'*/
	{ 0x44  ,  0x00 },   /*'`'*/
	{ 0x0e  ,  0xae },   /*'a'*/
	{ 0x9a  ,  0xba },   /*'b'*/
	{ 0x0e  ,  0x8c },   /*'c'*/
	{ 0x2e  ,  0xae },   /*'d'*/
	{ 0x0e  ,  0xce },   /*'e'*/
	{ 0x56  ,  0xd0 },   /*'f'*/
	{ 0x55  ,  0x3B },   /*'g'*/
	{ 0x93  ,  0xb4 },   /*'h'*/
	{ 0x41  ,  0x44 },   /*'i'*/
	{ 0x41  ,  0x51 },   /*'j'*/
	{ 0x97  ,  0xb4 },   /*'k'*/
	{ 0x49  ,  0x44 },   /*'l'*/
	{ 0x17  ,  0xb6 },   /*'m'*/
	{ 0x1a  ,  0xb6 },   /*'n'*/
	{ 0x0a  ,  0xaa },   /*'o'*/
	{ 0xd6  ,  0xd3 },   /*'p'*/
	{ 0x76  ,  0x67 },   /*'q'*/
	{ 0x17  ,  0x90 },   /*'r'*/
	{ 0x0f  ,  0x38 },   /*'s'*/
	{ 0x9a  ,  0x8c },   /*'t'*/
	{ 0x16  ,  0xae },   /*'u'*/
	{ 0x16  ,  0xba },   /*'v'*/
	{ 0x16  ,  0xf6 },   /*'w'*/
	{ 0x15  ,  0xb4 },   /*'x'*/
	{ 0xb5  ,  0x2b },   /*'y'*/
	{ 0x1c  ,  0x5e },   /*'z'*/
	{ 0x6b  ,  0x4c },   /*'{'*/
	{ 0x49  ,  0x48 },   /*'|'*/
	{ 0xc9  ,  0x5a },   /*'}'*/
	{ 0x54  ,  0x00 },   /*'~'*/
	{ 0x56  ,  0xe2 }    /*''*/
};

// Font retreival function - ugly, but needed.

static int PrintX, PrintY;

static void DrawChar(char c)
{
	if ((unsigned char)c < 32 || (unsigned char)c > 127) c = '?';
	const uint8_t index = ((unsigned char)(c)) - 32;
	uint8_t data1 = pgm_read_byte(&font4x6[index][0]);
	uint8_t data2 = pgm_read_byte(&font4x6[index][1]);
	int y = PrintY;

	if (data2 & 1)	// Descender e.g. j, g
	{
		PutPixel(PrintX, y, 1);
		PutPixel(PrintX + 1, y, 1);
		PutPixel(PrintX + 2, y, 1);
		PutPixel(PrintX + 3, y, 1);
		y++;

		PutPixel(PrintX, y, (data1 & 0x80) ? 0 : 1);
		PutPixel(PrintX + 1, y, (data1 & 0x40) ? 0 : 1);
		PutPixel(PrintX + 2, y, (data1 & 0x20) ? 0 : 1);
		PutPixel(PrintX + 3, y, 1);
		y++;

		PutPixel(PrintX, y, (data1 & 0x10) ? 0 : 1);
		PutPixel(PrintX + 1, y, (data1 & 0x8) ? 0 : 1);
		PutPixel(PrintX + 2, y, (data1 & 0x4) ? 0 : 1);
		PutPixel(PrintX + 3, y, 1);
		y++;

		PutPixel(PrintX, y, (data1 & 0x2) ? 0 : 1);
		PutPixel(PrintX + 1, y, (data1 & 0x1) ? 0 : 1);
		PutPixel(PrintX + 2, y, (data2 & 0x2) ? 0 : 1);
		PutPixel(PrintX + 3, y, 1);
		y++;

		PutPixel(PrintX, y, (data2 & 0x80) ? 0 : 1);
		PutPixel(PrintX + 1, y, (data2 & 0x40) ? 0 : 1);
		PutPixel(PrintX + 2, y, (data2 & 0x20) ? 0 : 1);
		PutPixel(PrintX + 3, y, 1);
		y++;

		PutPixel(PrintX, y, (data2 & 0x10) ? 0 : 1);
		PutPixel(PrintX + 1, y, (data2 & 0x8) ? 0 : 1);
		PutPixel(PrintX + 2, y, (data2 & 0x4) ? 0 : 1);
		PutPixel(PrintX + 3, y, 1);
		y++;
	}
	else
	{
		PutPixel(PrintX, y, (data1 & 0x80) ? 0 : 1);
		PutPixel(PrintX + 1, y, (data1 & 0x40) ? 0 : 1);
		PutPixel(PrintX + 2, y, (data1 & 0x20) ? 0 : 1);
		PutPixel(PrintX + 3, y, 1);
		y++;

		PutPixel(PrintX, y, (data1 & 0x10) ? 0 : 1);
		PutPixel(PrintX + 1, y, (data1 & 0x8) ? 0 : 1);
		PutPixel(PrintX + 2, y, (data1 & 0x4) ? 0 : 1);
		PutPixel(PrintX + 3, y, 1);
		y++;

		PutPixel(PrintX, y, (data1 & 0x2) ? 0 : 1);
		PutPixel(PrintX + 1, y, (data1 & 0x1) ? 0 : 1);
		PutPixel(PrintX + 2, y, (data2 & 0x2) ? 0 : 1);
		PutPixel(PrintX + 3, y, 1);
		y++;

		PutPixel(PrintX, y, (data2 & 0x80) ? 0 : 1);
		PutPixel(PrintX + 1, y, (data2 & 0x40) ? 0 : 1);
		PutPixel(PrintX + 2, y, (data2 & 0x20) ? 0 : 1);
		PutPixel(PrintX + 3, y, 1);
		y++;

		PutPixel(PrintX, y, (data2 & 0x10) ? 0 : 1);
		PutPixel(PrintX + 1, y, (data2 & 0x8) ? 0 : 1);
		PutPixel(PrintX + 2, y, (data2 & 0x4) ? 0 : 1);
		PutPixel(PrintX + 3, y, 1);
		y++;

		PutPixel(PrintX, y, 1);
		PutPixel(PrintX + 1, y, 1);
		PutPixel(PrintX + 2, y, 1);
		PutPixel(PrintX + 3, y, 1);
	}
}


static void DrawString(const char* str, uint8_t x, uint8_t y)
{
	PrintX = x;
	PrintY = y;

	for (;;)
	{
		char c = pgm_read_byte(str++);
		if (!c)
			break;

		DrawChar(c);
		PrintX += FONT_WIDTH;
	}
}


static void DrawInt(int32_t val, uint8_t x, uint8_t y)
{
    char number[12];
    rb->snprintf(number, sizeof(number), "%ld", (long)val);
    DrawString(number, x, y);
}

static uint8_t DrawCurrency(int32_t val, uint8_t x, uint8_t y)
{
    uint32_t magnitude = val < 0 ? 0u - (uint32_t)val : (uint32_t)val;
    unsigned digits = 0;
    uint8_t length = 0;
    PrintX = x; PrintY = y;
    do {
        if (digits && digits % 3 == 0) {
            DrawChar(','); PrintX -= FONT_WIDTH; ++length;
        }
        DrawChar('0' + magnitude % 10);
        PrintX -= FONT_WIDTH; ++length; ++digits;
        magnitude /= 10;
    } while (magnitude);
    if (val < 0) { DrawChar('-'); PrintX -= FONT_WIDTH; ++length; }
    DrawChar('$');
    return length + 1;
}


/* ---- Upstream Draw (adapted) ---- */

#ifdef MICROCITY_COLOR
/* Pokitto tiles retain the original tile IDs; each 8x8 tile is 32 bytes.
 * Palette colors reproduce upstream RGB565 values in Rockbox native format. */
static const fb_data ColorPalette[16] = {
    FB_RGBPACK(16, 12, 24),
    FB_RGBPACK(66, 36, 49),
    FB_RGBPACK(49, 52, 107),
    FB_RGBPACK(74, 73, 74),
    FB_RGBPACK(132, 77, 49),
    FB_RGBPACK(49, 101, 33),
    FB_RGBPACK(214, 69, 74),
    FB_RGBPACK(115, 113, 99),
    FB_RGBPACK(90, 125, 206),
    FB_RGBPACK(214, 125, 41),
    FB_RGBPACK(132, 150, 165),
    FB_RGBPACK(107, 170, 41),
    FB_RGBPACK(214, 170, 156),
    FB_RGBPACK(107, 195, 206),
    FB_RGBPACK(222, 215, 90),
    FB_RGBPACK(255, 255, 255)
};
static const uint8_t TileImageData[] = {
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x99, 0x99, 0x99, 0x99, 0x99, 0x49, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99,
    0x99, 0x99, 0x99, 0x49, 0x99, 0x49, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99,
    0x99, 0x99, 0x99, 0x99, 0x94, 0x99, 0x99, 0x99, 0x99, 0x99, 0x94, 0x99, 0x99, 0x99, 0x99, 0x99,
    0x99, 0x99, 0x99, 0x99, 0x99, 0x94, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99,
    0x99, 0x99, 0x99, 0x99, 0x99, 0x49, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99,
    0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x49, 0x99, 0x99, 0x99, 0x99, 0x99,
    0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x49, 0x99, 0x99, 0x99, 0x99, 0x99, 0x94, 0x99, 0x99,
    0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x94, 0x99, 0x99, 0x99, 0x99, 0x99,
    0x99, 0x99, 0x99, 0x99, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
    0x3f, 0xf3, 0x3f, 0xf3, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
    0x93, 0x33, 0x33, 0x33, 0x93, 0x33, 0xf3, 0x33, 0x93, 0x33, 0xf3, 0x33, 0x93, 0x33, 0x33, 0x33,
    0x93, 0x33, 0x33, 0x33, 0x93, 0x33, 0xf3, 0x33, 0x93, 0x33, 0xf3, 0x33, 0x93, 0x33, 0x33, 0x33,
    0x99, 0x99, 0x99, 0x99, 0x99, 0x93, 0x33, 0x33, 0x99, 0x33, 0x33, 0x33, 0x93, 0x33, 0x33, 0x33,
    0x93, 0x33, 0x3f, 0xf3, 0x93, 0x33, 0xf3, 0x33, 0x93, 0x33, 0xf3, 0x33, 0x93, 0x33, 0x33, 0x33,
    0x99, 0x99, 0x99, 0x99, 0x33, 0x33, 0x33, 0x99, 0x33, 0x33, 0x33, 0x39, 0x33, 0x33, 0x33, 0x33,
    0x3f, 0xf3, 0x33, 0x33, 0x33, 0x33, 0xf3, 0x33, 0x33, 0x33, 0xf3, 0x33, 0x33, 0x33, 0x33, 0x33,
    0x93, 0x33, 0x33, 0x33, 0x33, 0x33, 0xf3, 0x33, 0x33, 0x33, 0xf3, 0x33, 0x33, 0x33, 0x33, 0x33,
    0x3f, 0xf3, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x39, 0x33, 0x33, 0x33, 0x99,
    0x93, 0x33, 0x33, 0x33, 0x93, 0x33, 0xf3, 0x33, 0x93, 0x33, 0xf3, 0x33, 0x93, 0x33, 0x33, 0x33,
    0x93, 0x33, 0x3f, 0xf3, 0x93, 0x33, 0x33, 0x33, 0x99, 0x33, 0x33, 0x33, 0x99, 0x93, 0x33, 0x33,
    0x99, 0x99, 0x99, 0x99, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
    0x3f, 0xf3, 0x3f, 0xf3, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xf3, 0xf3,
    0x93, 0x33, 0x33, 0x33, 0x33, 0x33, 0xf3, 0x33, 0x33, 0x33, 0xf3, 0x33, 0x33, 0x33, 0x33, 0x33,
    0xf3, 0x33, 0x33, 0x33, 0x33, 0x33, 0xf3, 0x33, 0xf3, 0x33, 0xf3, 0x33, 0x33, 0x33, 0x33, 0x33,
    0xf3, 0xf3, 0xf3, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
    0x3f, 0xf3, 0x3f, 0xf3, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
    0x93, 0x33, 0x33, 0x33, 0x93, 0x33, 0xf3, 0x33, 0x93, 0x33, 0xf3, 0x3f, 0x93, 0x33, 0x33, 0x33,
    0x93, 0x33, 0x33, 0x3f, 0x93, 0x33, 0xf3, 0x33, 0x93, 0x33, 0xf3, 0x33, 0x93, 0x33, 0x33, 0x33,
    0xf3, 0xf3, 0xf3, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3f, 0x33, 0x33, 0x33, 0x33,
    0xf3, 0x33, 0x33, 0x3f, 0x33, 0x33, 0x33, 0x33, 0xf3, 0x33, 0x33, 0x33, 0x33, 0x33, 0xf3, 0xf3,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0x88, 0x88, 0x88, 0x88, 0x88, 0xdd, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0xdd, 0x88, 0x88, 0xff,
    0x88, 0x88, 0x88, 0x88, 0x88, 0x8d, 0xd8, 0x88, 0x88, 0x88, 0x88, 0x88, 0xdd, 0xd8, 0x88, 0x8f,
    0x88, 0x88, 0x88, 0x88, 0x88, 0xdd, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0xf8, 0x88, 0x88, 0x8d,
    0x88, 0x88, 0x88, 0x88, 0x88, 0xff, 0xff, 0x88, 0x88, 0x88, 0x88, 0x88, 0xff, 0xf8, 0x88, 0x8f,
    0x88, 0x88, 0x88, 0x88, 0x8f, 0xff, 0xf8, 0x88, 0x88, 0x88, 0x88, 0x88, 0xd8, 0x88, 0x88, 0x8f,
    0x88, 0x88, 0x88, 0x88, 0x88, 0xff, 0xff, 0x88, 0x88, 0x88, 0x88, 0x88, 0xff, 0x88, 0x88, 0x88,
    0x88, 0x88, 0x88, 0x88, 0x8f, 0xff, 0xf8, 0x88, 0x88, 0x88, 0x88, 0x88, 0xff, 0x88, 0x88, 0xdd,
    0x88, 0x88, 0x88, 0x88, 0x88, 0x8d, 0xd8, 0x88, 0x88, 0x88, 0x88, 0x88, 0xdd, 0x88, 0x88, 0x88,
    0x99, 0x99, 0x99, 0x99, 0x33, 0x33, 0x33, 0x33, 0x3a, 0x3a, 0x3a, 0x3a, 0x33, 0x33, 0x33, 0x33,
    0x3f, 0xf3, 0x3f, 0xf3, 0x33, 0x33, 0x33, 0x33, 0xa3, 0xa3, 0xa3, 0xa3, 0x33, 0x33, 0x33, 0x33,
    0x93, 0xa3, 0x33, 0x33, 0x93, 0x33, 0xf3, 0xa3, 0x93, 0xa3, 0xf3, 0x33, 0x93, 0x33, 0x33, 0xa3,
    0x93, 0xa3, 0x33, 0x33, 0x93, 0x33, 0xf3, 0xa3, 0x93, 0xa3, 0xf3, 0x33, 0x93, 0x33, 0x33, 0xa3,
    0x99, 0x99, 0x99, 0x99, 0x99, 0x93, 0x33, 0x33, 0x99, 0x33, 0x3a, 0x3a, 0x93, 0x3a, 0x33, 0x33,
    0x93, 0x33, 0x3f, 0xf3, 0x93, 0x33, 0xf3, 0x33, 0x93, 0xa3, 0xf3, 0x33, 0x93, 0x33, 0x33, 0xa3,
    0x99, 0x99, 0x99, 0x99, 0x33, 0x33, 0x33, 0x99, 0x3a, 0x3a, 0x33, 0x39, 0x33, 0x33, 0x3a, 0x33,
    0x3f, 0xf3, 0x33, 0x33, 0x33, 0x33, 0xf3, 0xa3, 0xa3, 0xa3, 0xf3, 0x33, 0x33, 0x33, 0x33, 0xa3,
    0x93, 0xa3, 0x33, 0x33, 0x33, 0x33, 0xf3, 0xa3, 0x3a, 0x33, 0xf3, 0x33, 0x33, 0x33, 0x33, 0xa3,
    0x3f, 0xf3, 0x33, 0x33, 0x33, 0x33, 0xa3, 0x33, 0xa3, 0xa3, 0x33, 0x39, 0x33, 0x33, 0x33, 0x99,
    0x93, 0xa3, 0x33, 0x33, 0x93, 0x33, 0xf3, 0xa3, 0x93, 0xa3, 0xf3, 0x33, 0x93, 0x33, 0x33, 0x33,
    0x93, 0xa3, 0x3f, 0xf3, 0x93, 0x33, 0x33, 0x33, 0x99, 0x33, 0xa3, 0xa3, 0x99, 0x93, 0x33, 0x33,
    0x99, 0x99, 0x99, 0x99, 0x33, 0x33, 0x33, 0x33, 0x3a, 0x3a, 0x3a, 0x3a, 0x33, 0x33, 0x33, 0x33,
    0x3f, 0xf3, 0x3f, 0xf3, 0x33, 0x33, 0x33, 0x33, 0xa3, 0xa3, 0xa3, 0xa3, 0x33, 0x33, 0xf3, 0xf3,
    0x93, 0xa3, 0x33, 0x33, 0x33, 0x33, 0xf3, 0xa3, 0x33, 0xa3, 0xf3, 0x33, 0x33, 0x33, 0x33, 0xa3,
    0xf3, 0xa3, 0x33, 0x33, 0x33, 0x33, 0xf3, 0xa3, 0xf3, 0xa3, 0xf3, 0x33, 0x33, 0x33, 0x33, 0xa3,
    0xf3, 0xf3, 0xf3, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3a, 0x3a, 0x3a, 0x3a, 0x33, 0x33, 0x33, 0x33,
    0x3f, 0xf3, 0x3f, 0xf3, 0x33, 0x33, 0x33, 0x33, 0xa3, 0xa3, 0xa3, 0xa3, 0x33, 0x33, 0x33, 0x33,
    0x93, 0xa3, 0x33, 0x33, 0x93, 0x33, 0xf3, 0xa3, 0x93, 0xa3, 0xf3, 0x3f, 0x93, 0x33, 0x33, 0xa3,
    0x93, 0xa3, 0x33, 0x3f, 0x93, 0x33, 0xf3, 0xa3, 0x93, 0xa3, 0xf3, 0x33, 0x93, 0x33, 0x33, 0xa3,
    0xf3, 0xf3, 0xf3, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3a, 0x33, 0x33, 0xaf, 0x33, 0x33, 0x33, 0x33,
    0xf3, 0x33, 0x33, 0x3f, 0x33, 0x33, 0x33, 0x33, 0xf3, 0xa3, 0x33, 0x33, 0x33, 0x33, 0xf3, 0xf3,
    0x88, 0x88, 0x88, 0x88, 0xaa, 0xaa, 0xaa, 0xaa, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
    0x3f, 0xf3, 0x3f, 0xf3, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xaa, 0xaa, 0xaa, 0xaa,
    0x7a, 0x33, 0x33, 0x3a, 0x8a, 0x33, 0xf3, 0x3a, 0x7a, 0x33, 0xf3, 0x3a, 0x8a, 0x33, 0x33, 0x3a,
    0x7a, 0x33, 0x33, 0x3a, 0x8a, 0x33, 0xf3, 0x3a, 0x7a, 0x33, 0xf3, 0x3a, 0x8a, 0x33, 0x33, 0x3a,
    0x88, 0x88, 0x88, 0x88, 0xaa, 0xaa, 0xaa, 0xaa, 0x88, 0x88, 0x88, 0x88, 0xaa, 0xaa, 0xaa, 0xaa,
    0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0xff, 0x88, 0x88, 0x88, 0x88, 0x88, 0xff, 0x88, 0x88, 0x88,
    0x88, 0x8a, 0x8a, 0x88, 0x88, 0x8a, 0x8a, 0x88, 0x88, 0x8a, 0x8a, 0x88, 0xf8, 0x8a, 0x8a, 0x8f,
    0x88, 0x8a, 0x8a, 0x88, 0x88, 0x8a, 0x8a, 0x88, 0x88, 0x8a, 0x8a, 0x88, 0xff, 0x8a, 0x8a, 0x88,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0x99, 0x99, 0x99, 0x99, 0x33, 0x33, 0x33, 0x33, 0xa3, 0xa3, 0xa3, 0xa3, 0x33, 0x33, 0x33, 0x33,
    0x3f, 0xf3, 0x3f, 0xf3, 0x33, 0x33, 0x33, 0x33, 0x3a, 0x3a, 0x3a, 0x3a, 0x33, 0x33, 0x33, 0x33,
    0x93, 0x33, 0x33, 0xa3, 0x93, 0xa3, 0xf3, 0x33, 0x93, 0x33, 0xf3, 0xa3, 0x93, 0xa3, 0x33, 0x33,
    0x93, 0x33, 0x33, 0xa3, 0x93, 0xa3, 0xf3, 0x33, 0x93, 0x33, 0xf3, 0xa3, 0x93, 0xa3, 0x33, 0x33,
    0x99, 0x99, 0x99, 0x99, 0x99, 0x93, 0x33, 0x33, 0x99, 0x33, 0xa3, 0xa3, 0x93, 0x33, 0x33, 0x33,
    0x93, 0xa3, 0x3f, 0xf3, 0x93, 0x33, 0xf3, 0x33, 0x93, 0x33, 0xf3, 0x33, 0x93, 0xa3, 0x33, 0x33,
    0x99, 0x99, 0x99, 0x99, 0x33, 0x33, 0x33, 0x99, 0xa3, 0xa3, 0xa3, 0x39, 0x33, 0x33, 0x33, 0x33,
    0x3f, 0xf3, 0x33, 0xa3, 0x33, 0x33, 0xf3, 0x33, 0x3a, 0x33, 0xf3, 0xa3, 0x33, 0xa3, 0x33, 0x33,
    0x93, 0x33, 0x33, 0xa3, 0x33, 0xa3, 0xf3, 0x33, 0xa3, 0x33, 0xf3, 0xa3, 0x33, 0x33, 0x33, 0x33,
    0x3f, 0xf3, 0x3a, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3a, 0x3a, 0x33, 0x39, 0x33, 0x33, 0x33, 0x99,
    0x93, 0x33, 0x33, 0xa3, 0x93, 0xa3, 0xf3, 0x33, 0x93, 0x33, 0xf3, 0x33, 0x93, 0xa3, 0x33, 0x33,
    0x93, 0x33, 0x3f, 0xf3, 0x93, 0x3a, 0x33, 0x33, 0x99, 0x33, 0x3a, 0x3a, 0x99, 0x93, 0x33, 0x33,
    0x99, 0x99, 0x99, 0x99, 0x33, 0x33, 0x33, 0x33, 0xa3, 0xa3, 0xa3, 0xa3, 0x33, 0x33, 0x33, 0x33,
    0x3f, 0xf3, 0x3f, 0xf3, 0x33, 0x33, 0x33, 0x33, 0x3a, 0x3a, 0x3a, 0x3a, 0x33, 0x33, 0xf3, 0xf3,
    0x93, 0x33, 0x33, 0xa3, 0x33, 0xa3, 0xf3, 0x33, 0x33, 0x33, 0xf3, 0xa3, 0x33, 0xa3, 0x33, 0x33,
    0xf3, 0x33, 0x33, 0xa3, 0x33, 0xa3, 0xf3, 0x33, 0xf3, 0x33, 0xf3, 0xa3, 0x33, 0xa3, 0x33, 0x33,
    0xf3, 0xf3, 0xf3, 0x33, 0x33, 0x33, 0x33, 0x33, 0xa3, 0xa3, 0xa3, 0xa3, 0x33, 0x33, 0x33, 0x33,
    0x3f, 0xf3, 0x3f, 0xf3, 0x33, 0x33, 0x33, 0x33, 0x3a, 0x3a, 0x3a, 0x3a, 0x33, 0x33, 0x33, 0x33,
    0x93, 0x33, 0x33, 0xa3, 0x93, 0xa3, 0xf3, 0x33, 0x93, 0x33, 0xf3, 0xaf, 0x93, 0xa3, 0x33, 0x33,
    0x93, 0x33, 0x33, 0xaf, 0x93, 0xa3, 0xf3, 0x33, 0x93, 0x33, 0xf3, 0xa3, 0x93, 0xa3, 0x33, 0x33,
    0xf3, 0xf3, 0xf3, 0x33, 0x33, 0xa3, 0x3a, 0x33, 0x33, 0x33, 0x33, 0x3f, 0x33, 0x33, 0x33, 0x33,
    0xf3, 0x33, 0x33, 0x3f, 0x33, 0x33, 0x33, 0x33, 0xfa, 0x33, 0x33, 0x33, 0x33, 0x33, 0xf3, 0xf3,
    0xff, 0xff, 0xff, 0xf3, 0xf6, 0x66, 0xe6, 0x63, 0xf6, 0x6e, 0x66, 0x63, 0xf6, 0xe6, 0x66, 0x63,
    0xf6, 0xee, 0xee, 0x63, 0xf6, 0x66, 0xe6, 0x63, 0xf6, 0x6e, 0x66, 0x63, 0x33, 0x33, 0x33, 0x33,
    0x99, 0x9a, 0x9a, 0x99, 0x33, 0x3a, 0x3a, 0x33, 0x33, 0x3a, 0x3a, 0x33, 0x33, 0x3a, 0x3a, 0x33,
    0x3f, 0xfa, 0x3a, 0xf3, 0x33, 0x3a, 0x3a, 0x33, 0x33, 0x3a, 0x3a, 0x33, 0x33, 0x3a, 0x3a, 0x33,
    0x93, 0x33, 0x33, 0x33, 0xaa, 0xaa, 0xaa, 0xaa, 0x93, 0x33, 0xf3, 0x33, 0xaa, 0xaa, 0xaa, 0xaa,
    0x93, 0x33, 0x33, 0x33, 0x93, 0x33, 0xf3, 0x33, 0x93, 0x33, 0xf3, 0x33, 0x93, 0x33, 0x33, 0x33,
    0x99, 0x49, 0x49, 0x99, 0x49, 0x99, 0x99, 0x49, 0x99, 0x94, 0x99, 0x99, 0x94, 0x99, 0x94, 0x99,
    0x99, 0x99, 0x99, 0x99, 0x99, 0x49, 0x99, 0x94, 0x99, 0x99, 0x94, 0x99, 0x49, 0x99, 0x99, 0x99,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0x99, 0x99, 0x99, 0x99, 0xaa, 0xaa, 0xaa, 0xaa, 0x99, 0x94, 0x49, 0x99, 0xaa, 0xaa, 0xaa, 0xaa,
    0x99, 0x94, 0x49, 0x99, 0x99, 0x94, 0x49, 0x99, 0x99, 0x94, 0x49, 0x99, 0x99, 0x99, 0x99, 0x99,
    0x99, 0x9a, 0x9a, 0x99, 0x99, 0x9a, 0x9a, 0x99, 0x99, 0x9a, 0x9a, 0x99, 0x99, 0x9a, 0x9a, 0x99,
    0x99, 0x9a, 0x9a, 0x99, 0x99, 0x9a, 0x9a, 0x99, 0x99, 0x9a, 0x9a, 0x99, 0x99, 0x9a, 0x9a, 0x99,
    0x99, 0x99, 0x99, 0x99, 0x99, 0x9a, 0xaa, 0xaa, 0x99, 0x9a, 0x99, 0x99, 0x99, 0x9a, 0x9a, 0xaa,
    0x99, 0x9a, 0x9a, 0x99, 0x99, 0x9a, 0x9a, 0x99, 0x99, 0x9a, 0x9a, 0x99, 0x99, 0x9a, 0x9a, 0x99,
    0x99, 0x99, 0x99, 0x99, 0xaa, 0xaa, 0xaa, 0x99, 0x99, 0x99, 0x9a, 0x99, 0xaa, 0xaa, 0x9a, 0x99,
    0x99, 0x9a, 0x9a, 0x99, 0x99, 0x9a, 0x9a, 0x99, 0x99, 0x9a, 0x9a, 0x99, 0x99, 0x9a, 0x9a, 0x99,
    0x99, 0x9a, 0x9a, 0x99, 0xaa, 0xaa, 0x9a, 0x99, 0x99, 0x94, 0x4a, 0x99, 0xaa, 0xaa, 0xaa, 0x99,
    0x99, 0x94, 0x49, 0x99, 0x99, 0x94, 0x49, 0x99, 0x99, 0x94, 0x49, 0x99, 0x99, 0x99, 0x99, 0x99,
    0x99, 0x9a, 0x9a, 0x99, 0x99, 0x9a, 0x9a, 0xaa, 0x99, 0x9a, 0x44, 0x99, 0x99, 0x9a, 0xaa, 0xaa,
    0x99, 0x99, 0x44, 0x99, 0x99, 0x99, 0x44, 0x99, 0x99, 0x99, 0x44, 0x99, 0x99, 0x99, 0x99, 0x99,
    0x99, 0x99, 0x99, 0x99, 0xaa, 0xaa, 0xaa, 0xaa, 0x99, 0x99, 0x99, 0x99, 0xaa, 0xaa, 0x9a, 0xaa,
    0x99, 0x9a, 0x9a, 0x99, 0x99, 0x9a, 0x9a, 0x99, 0x99, 0x9a, 0x9a, 0x99, 0x99, 0x9a, 0x9a, 0x99,
    0x99, 0x9a, 0x9a, 0x99, 0xaa, 0xaa, 0x9a, 0x99, 0x99, 0x99, 0x9a, 0x99, 0xaa, 0xaa, 0x9a, 0x99,
    0x99, 0x9a, 0x9a, 0x99, 0x99, 0x9a, 0x9a, 0x99, 0x99, 0x9a, 0x9a, 0x99, 0x99, 0x9a, 0x9a, 0x99,
    0x99, 0x9a, 0x9a, 0x99, 0xaa, 0xaa, 0x9a, 0xaa, 0x99, 0x99, 0x99, 0x99, 0xaa, 0xaa, 0xaa, 0xaa,
    0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99,
    0x99, 0x9a, 0x9a, 0x99, 0x99, 0x9a, 0x9a, 0xaa, 0x99, 0x9a, 0x99, 0x99, 0x99, 0x9a, 0x9a, 0xaa,
    0x99, 0x9a, 0x9a, 0x99, 0x99, 0x9a, 0x9a, 0x99, 0x99, 0x9a, 0x9a, 0x99, 0x99, 0x9a, 0x9a, 0x99,
    0x99, 0x9a, 0x9a, 0x99, 0xaa, 0xaa, 0x9a, 0xaa, 0x99, 0x99, 0x99, 0x99, 0xaa, 0xaa, 0x9a, 0xaa,
    0x99, 0x9a, 0x9a, 0x99, 0x99, 0x9a, 0x9a, 0x99, 0x99, 0x9a, 0x9a, 0x99, 0x99, 0x9a, 0x9a, 0x99,
    0x99, 0x99, 0x99, 0x99, 0x9b, 0xbb, 0xbb, 0xbb, 0x9b, 0x99, 0x99, 0x99, 0x9b, 0x99, 0x99, 0x99,
    0x9b, 0x99, 0x99, 0x99, 0x9b, 0x99, 0x99, 0x99, 0x9b, 0x99, 0x99, 0x99, 0x9b, 0x99, 0x99, 0x99,
    0x99, 0x99, 0x99, 0x99, 0xbb, 0xbb, 0xbb, 0xbb, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99,
    0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99,
    0x99, 0x99, 0x99, 0x99, 0xbb, 0xbb, 0xbb, 0xbb, 0x99, 0x99, 0x99, 0x9b, 0x99, 0x99, 0x99, 0x9b,
    0x99, 0x99, 0x99, 0x9b, 0x99, 0x99, 0x99, 0x9b, 0x99, 0x99, 0x99, 0x9b, 0x99, 0x99, 0x99, 0x9b,
    0x99, 0x99, 0x99, 0x99, 0x98, 0x88, 0x88, 0x88, 0x98, 0x99, 0x99, 0x99, 0x98, 0x99, 0x99, 0x99,
    0x98, 0x99, 0x99, 0x99, 0x98, 0x99, 0x99, 0x99, 0x98, 0x99, 0x99, 0x99, 0x98, 0x99, 0x99, 0x99,
    0x99, 0x99, 0x99, 0x99, 0x88, 0x88, 0x88, 0x88, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99,
    0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99,
    0x99, 0x99, 0x99, 0x99, 0x88, 0x88, 0x88, 0x88, 0x99, 0x99, 0x99, 0x98, 0x99, 0x99, 0x99, 0x98,
    0x99, 0x99, 0x99, 0x98, 0x99, 0x99, 0x99, 0x98, 0x99, 0x99, 0x99, 0x98, 0x99, 0x99, 0x99, 0x98,
    0x99, 0x99, 0x99, 0x99, 0x9e, 0xee, 0xee, 0xee, 0x9e, 0x99, 0x99, 0x99, 0x9e, 0x99, 0x99, 0x99,
    0x9e, 0x99, 0x99, 0x99, 0x9e, 0x99, 0x99, 0x99, 0x9e, 0x99, 0x99, 0x99, 0x9e, 0x99, 0x99, 0x99,
    0x99, 0x99, 0x99, 0x99, 0xee, 0xee, 0xee, 0xee, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99,
    0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99,
    0x99, 0x99, 0x99, 0x99, 0xee, 0xee, 0xee, 0xee, 0x99, 0x99, 0x99, 0x9e, 0x99, 0x99, 0x99, 0x9e,
    0x99, 0x99, 0x99, 0x9e, 0x99, 0x99, 0x99, 0x9e, 0x99, 0x99, 0x99, 0x9e, 0x99, 0x99, 0x99, 0x9e,
    0x99, 0x99, 0x99, 0x99, 0x94, 0x55, 0x44, 0x44, 0x95, 0x5b, 0x5b, 0xb5, 0x95, 0xb5, 0x5b, 0xb5,
    0x94, 0x55, 0xbb, 0xbb, 0x94, 0xbb, 0xb5, 0x5b, 0x94, 0xbb, 0x5b, 0x55, 0x94, 0xbb, 0x55, 0xb5,
    0x99, 0x99, 0x99, 0x99, 0x55, 0x7a, 0xa7, 0x44, 0xb5, 0x5a, 0xa7, 0xbb, 0x5b, 0x5a, 0xa7, 0xb5,
    0x55, 0x7a, 0xa7, 0xb5, 0xbb, 0x7a, 0xa7, 0xbb, 0xb6, 0x7a, 0xa7, 0x6b, 0x6b, 0x7a, 0xa7, 0xbb,
    0x99, 0x99, 0x99, 0x99, 0x44, 0x44, 0x44, 0x44, 0x55, 0xbb, 0xbb, 0x64, 0x5b, 0x5b, 0x6b, 0xb4,
    0xb5, 0x5b, 0xbb, 0xb4, 0x55, 0xbb, 0xb5, 0x54, 0xbb, 0xbb, 0x55, 0xb5, 0xb5, 0x5b, 0x5b, 0x55,
    0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0xaa, 0xaa, 0x99, 0x92, 0xa8, 0x88, 0x99, 0x22, 0xa8, 0x88,
    0x92, 0x22, 0xa8, 0x88, 0x92, 0x22, 0xa8, 0x88, 0x92, 0x22, 0xa8, 0x88, 0x92, 0x22, 0xa8, 0x88,
    0x99, 0x99, 0x99, 0x99, 0xaa, 0x99, 0x99, 0x99, 0x8a, 0x99, 0x99, 0x99, 0x8a, 0xaa, 0xaa, 0xaa,
    0x88, 0x88, 0x88, 0x88, 0x8f, 0xff, 0x88, 0xff, 0x8f, 0x22, 0xf8, 0xf2, 0x8f, 0x88, 0xf8, 0xf8,
    0x99, 0x99, 0x99, 0x99, 0x99, 0xaa, 0xaa, 0xaa, 0x99, 0xa8, 0x88, 0x8a, 0xaa, 0xa8, 0x88, 0x8a,
    0x88, 0x88, 0x88, 0x8a, 0xf8, 0x88, 0x88, 0x8a, 0x2f, 0x88, 0x88, 0x8a, 0x8f, 0x88, 0x88, 0x8a,
    0x88, 0x88, 0x88, 0x89, 0x88, 0x88, 0x89, 0x99, 0x88, 0x88, 0x89, 0x99, 0x88, 0x88, 0x99, 0x99,
    0x88, 0x99, 0x99, 0x49, 0x89, 0x99, 0x99, 0x99, 0x89, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99,
    0x9b, 0x99, 0x99, 0x99, 0x9b, 0x99, 0x99, 0x99, 0x9b, 0x99, 0x99, 0x99, 0x9b, 0x99, 0x99, 0x99,
    0x9b, 0x99, 0x99, 0x99, 0x9b, 0x99, 0x99, 0x99, 0x9b, 0x99, 0x99, 0x99, 0x9b, 0x99, 0x99, 0x99,
    0x99, 0x99, 0x99, 0x99, 0x99, 0xbb, 0xb9, 0x99, 0x99, 0xb4, 0x4b, 0x99, 0x99, 0xb9, 0x9b, 0x99,
    0x99, 0xbb, 0xb4, 0x99, 0x99, 0xb4, 0x4b, 0x99, 0x99, 0xb9, 0x9b, 0x99, 0x99, 0x49, 0x94, 0x99,
    0x99, 0x99, 0x99, 0x9b, 0x99, 0x99, 0x99, 0x9b, 0x99, 0x99, 0x99, 0x9b, 0x99, 0x99, 0x99, 0x9b,
    0x99, 0x99, 0x99, 0x9b, 0x99, 0x99, 0x99, 0x9b, 0x99, 0x99, 0x99, 0x9b, 0x99, 0x99, 0x99, 0x9b,
    0x98, 0x99, 0x99, 0x99, 0x98, 0x99, 0x99, 0x99, 0x98, 0x99, 0x99, 0x99, 0x98, 0x99, 0x99, 0x99,
    0x98, 0x99, 0x99, 0x99, 0x98, 0x99, 0x99, 0x99, 0x98, 0x99, 0x99, 0x99, 0x98, 0x99, 0x99, 0x99,
    0x99, 0x99, 0x99, 0x99, 0x99, 0x98, 0x89, 0x99, 0x99, 0x84, 0x48, 0x99, 0x99, 0x89, 0x94, 0x99,
    0x99, 0x89, 0x99, 0x99, 0x99, 0x89, 0x98, 0x99, 0x99, 0x48, 0x84, 0x99, 0x99, 0x94, 0x49, 0x99,
    0x99, 0x99, 0x99, 0x98, 0x99, 0x99, 0x99, 0x98, 0x99, 0x99, 0x99, 0x98, 0x99, 0x99, 0x99, 0x98,
    0x99, 0x99, 0x99, 0x98, 0x99, 0x99, 0x99, 0x98, 0x99, 0x99, 0x99, 0x98, 0x99, 0x99, 0x99, 0x98,
    0x9e, 0x99, 0x99, 0x99, 0x9e, 0x99, 0x99, 0x99, 0x9e, 0x99, 0x99, 0x99, 0x9e, 0x99, 0x99, 0x99,
    0x9e, 0x99, 0x99, 0x99, 0x9e, 0x99, 0x99, 0x99, 0x9e, 0x99, 0x99, 0x99, 0x9e, 0x99, 0x99, 0x99,
    0x99, 0x99, 0x99, 0x99, 0x99, 0xee, 0xe9, 0x99, 0x99, 0x4e, 0x49, 0x99, 0x99, 0x9e, 0x99, 0x99,
    0x99, 0x9e, 0x99, 0x99, 0x99, 0x9e, 0x99, 0x99, 0x99, 0xee, 0xe9, 0x99, 0x99, 0x44, 0x49, 0x99,
    0x99, 0x99, 0x99, 0x9e, 0x99, 0x99, 0x99, 0x9e, 0x99, 0x99, 0x99, 0x9e, 0x99, 0x99, 0x99, 0x9e,
    0x99, 0x99, 0x99, 0x9e, 0x99, 0x99, 0x99, 0x9e, 0x99, 0x99, 0x99, 0x9e, 0x99, 0x99, 0x99, 0x9e,
    0x94, 0xbb, 0xb5, 0x5b, 0x94, 0xbb, 0xbb, 0xbb, 0x97, 0x77, 0x77, 0x77, 0x9a, 0xaa, 0xaa, 0xaa,
    0x9a, 0xaa, 0xaa, 0xaa, 0x97, 0x77, 0x75, 0x57, 0x94, 0xbb, 0x55, 0xb5, 0x94, 0xbb, 0x5b, 0x55,
    0xbb, 0x7a, 0xa7, 0xbb, 0xb7, 0xaa, 0xaa, 0x7b, 0x7a, 0xa8, 0x8a, 0xa7, 0xaa, 0x88, 0xd8, 0xaa,
    0xaa, 0x88, 0x88, 0xaa, 0x7a, 0xa8, 0x8a, 0xa7, 0xb7, 0xaa, 0xaa, 0x7b, 0xbb, 0x7a, 0xa7, 0xb5,
    0x55, 0xb5, 0xb5, 0x54, 0x5b, 0x55, 0xbb, 0xb4, 0x75, 0x57, 0x77, 0x77, 0xaa, 0xaa, 0xaa, 0xaa,
    0xaa, 0xaa, 0xaa, 0xaa, 0x77, 0x77, 0x75, 0x57, 0x55, 0xbb, 0x55, 0xb5, 0xb5, 0x5b, 0x5b, 0x55,
    0x92, 0x22, 0xa8, 0x88, 0x92, 0x22, 0xa8, 0x88, 0x92, 0x22, 0xa8, 0x88, 0x92, 0x22, 0xa8, 0x88,
    0x92, 0x22, 0xaa, 0xaa, 0x92, 0x22, 0x88, 0x88, 0x92, 0x28, 0x88, 0x88, 0x92, 0x88, 0x88, 0x88,
    0x8f, 0xff, 0x28, 0xf8, 0x8f, 0x22, 0x88, 0xf8, 0x8f, 0x88, 0x88, 0xff, 0x82, 0x88, 0x88, 0x22,
    0xaa, 0xaa, 0xaa, 0xaa, 0x88, 0x88, 0x88, 0x88, 0x88, 0xa8, 0x88, 0x8a, 0x82, 0xa8, 0x88, 0x8a,
    0x8f, 0x88, 0x88, 0x8a, 0x8f, 0x88, 0x88, 0x8a, 0xf2, 0x88, 0x88, 0x8a, 0x28, 0x88, 0x88, 0x8a,
    0xaa, 0xaa, 0xaa, 0xaa, 0x88, 0x88, 0x88, 0x89, 0x88, 0x88, 0x88, 0x99, 0x88, 0x88, 0x89, 0x99,
    0x98, 0x88, 0x88, 0x88, 0x99, 0x88, 0x88, 0x88, 0x99, 0x98, 0x88, 0x88, 0x99, 0x99, 0x98, 0x88,
    0x99, 0x99, 0x99, 0x88, 0x99, 0x94, 0x99, 0x98, 0x99, 0x99, 0x99, 0x98, 0x99, 0x99, 0x99, 0x99,
    0x9b, 0x99, 0x99, 0x99, 0x9b, 0x99, 0x99, 0x99, 0x9b, 0x99, 0x99, 0x99, 0x9b, 0x99, 0x99, 0x99,
    0x9b, 0x99, 0x99, 0x99, 0x9b, 0x99, 0x99, 0x99, 0x9b, 0x99, 0x99, 0x99, 0x9b, 0xbb, 0xbb, 0xbb,
    0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99,
    0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0xbb, 0xbb, 0xbb, 0xbb,
    0x99, 0x99, 0x99, 0x9b, 0x99, 0x99, 0x99, 0x9b, 0x99, 0x99, 0x99, 0x9b, 0x99, 0x99, 0x99, 0x9b,
    0x99, 0x99, 0x99, 0x9b, 0x99, 0x99, 0x99, 0x9b, 0x99, 0x99, 0x99, 0x9b, 0xbb, 0xbb, 0xbb, 0xbb,
    0x98, 0x99, 0x99, 0x99, 0x98, 0x99, 0x99, 0x99, 0x98, 0x99, 0x99, 0x99, 0x98, 0x99, 0x99, 0x99,
    0x98, 0x99, 0x99, 0x99, 0x98, 0x99, 0x99, 0x99, 0x98, 0x99, 0x99, 0x99, 0x98, 0x88, 0x88, 0x88,
    0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99,
    0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x88, 0x88, 0x88, 0x88,
    0x99, 0x99, 0x99, 0x98, 0x99, 0x99, 0x99, 0x98, 0x99, 0x99, 0x99, 0x98, 0x99, 0x99, 0x99, 0x98,
    0x99, 0x99, 0x99, 0x98, 0x99, 0x99, 0x99, 0x98, 0x99, 0x99, 0x99, 0x98, 0x88, 0x88, 0x88, 0x88,
    0x9e, 0x99, 0x99, 0x99, 0x9e, 0x99, 0x99, 0x99, 0x9e, 0x99, 0x99, 0x99, 0x9e, 0x99, 0x99, 0x99,
    0x9e, 0x99, 0x99, 0x99, 0x9e, 0x99, 0x99, 0x99, 0x9e, 0x99, 0x99, 0x99, 0x9e, 0xee, 0xee, 0xee,
    0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99,
    0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0xee, 0xee, 0xee, 0xee,
    0x99, 0x99, 0x99, 0x9e, 0x99, 0x99, 0x99, 0x9e, 0x99, 0x99, 0x99, 0x9e, 0x99, 0x99, 0x99, 0x9e,
    0x99, 0x99, 0x99, 0x9e, 0x99, 0x99, 0x99, 0x9e, 0x99, 0x99, 0x99, 0x9e, 0xee, 0xee, 0xee, 0xee,
    0x94, 0xbb, 0xb5, 0x5b, 0x94, 0xb6, 0xbb, 0xbb, 0x94, 0xbb, 0xbb, 0xb5, 0x94, 0x55, 0xbb, 0x5b,
    0x95, 0x5b, 0x5b, 0x55, 0x95, 0xb5, 0x5b, 0xb5, 0x94, 0x55, 0xbb, 0xbb, 0x94, 0x44, 0x44, 0x44,
    0x6b, 0x7a, 0xa7, 0xb5, 0xbb, 0x7a, 0xa7, 0xbb, 0x5b, 0x7a, 0xa7, 0xbb, 0x55, 0x7a, 0xa7, 0x6b,
    0xb5, 0x7a, 0xa7, 0xbb, 0x5b, 0x7a, 0xa7, 0xb6, 0xbb, 0x7a, 0xa7, 0xbb, 0x44, 0x7a, 0xa7, 0x44,
    0x5b, 0x5b, 0xb5, 0x54, 0x55, 0xbb, 0x6b, 0xb4, 0xbb, 0xbb, 0xbb, 0xb4, 0xbb, 0x55, 0xbb, 0x64,
    0xb5, 0x5b, 0x5b, 0xb4, 0xb5, 0xb5, 0x5b, 0xb4, 0xbb, 0x55, 0xbb, 0xb4, 0x44, 0x44, 0x44, 0x44,
    0x99, 0x99, 0x99, 0x99, 0x93, 0x33, 0x33, 0x39, 0x93, 0xd3, 0x3d, 0x39, 0x93, 0x33, 0x33, 0x39,
    0x93, 0x33, 0x33, 0x39, 0x93, 0xd3, 0xd3, 0x39, 0x93, 0x33, 0x33, 0x39, 0x99, 0x99, 0x99, 0x99,
    0x22, 0xa8, 0x88, 0x8a, 0x22, 0xa8, 0x88, 0x8a, 0x22, 0xa8, 0x88, 0x8a, 0x22, 0xaa, 0xaa, 0xaa,
    0x22, 0x88, 0x88, 0x89, 0x28, 0x8a, 0xa8, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99,
    0x99, 0x99, 0x99, 0x99, 0x93, 0x33, 0x33, 0x39, 0x93, 0xd3, 0xd3, 0x39, 0x93, 0x33, 0x33, 0x39,
    0x93, 0x33, 0x33, 0x39, 0x93, 0x3d, 0x3d, 0x39, 0x93, 0x33, 0x33, 0x39, 0x99, 0x99, 0x99, 0x99,
    0x99, 0x99, 0x99, 0x99, 0x89, 0x99, 0x99, 0x99, 0x89, 0x99, 0x49, 0x99, 0x88, 0x99, 0x99, 0x99,
    0x88, 0x89, 0x99, 0x99, 0x88, 0x88, 0x89, 0x99, 0x88, 0x88, 0x88, 0x99, 0x88, 0x88, 0x88, 0x89,
    0x99, 0x99, 0x99, 0x99, 0x99, 0x95, 0x55, 0x59, 0x99, 0x5b, 0xbb, 0xb5, 0x99, 0x5b, 0x88, 0xb3,
    0x99, 0x5b, 0x88, 0x33, 0x99, 0x5b, 0xb3, 0x33, 0x99, 0x95, 0x33, 0x33, 0x99, 0x93, 0x33, 0x03,
    0x99, 0xaa, 0xaa, 0xaa, 0x93, 0xaa, 0xaa, 0xaa, 0x33, 0xaa, 0xaa, 0xaa, 0x33, 0xaa, 0xaa, 0xaa,
    0x33, 0xaa, 0xaa, 0xab, 0x03, 0xaa, 0xaa, 0xab, 0x33, 0xaa, 0xaa, 0xab, 0x03, 0xaa, 0xaa, 0xab,
    0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa,
    0xbb, 0xaa, 0xaa, 0xaa, 0x55, 0xba, 0xaa, 0xaa, 0xaa, 0xba, 0xaa, 0xaa, 0xbb, 0x5a, 0xaa, 0xaa,
    0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x93, 0xaa, 0x99, 0x99, 0x33, 0xaa, 0x99, 0x93, 0x33, 0xaa,
    0x99, 0x33, 0x03, 0xaa, 0x93, 0x33, 0x33, 0xaa, 0x93, 0x03, 0x03, 0xaa, 0x93, 0x33, 0x33, 0xa8,
    0x99, 0x99, 0x99, 0x99, 0xa9, 0x99, 0x99, 0x99, 0xa9, 0x99, 0x99, 0x93, 0xaa, 0xaa, 0xaa, 0xa3,
    0xaa, 0xaa, 0xaa, 0xa3, 0xaa, 0xaa, 0xaa, 0xa3, 0xaa, 0xaa, 0xaa, 0xa3, 0x88, 0x88, 0x88, 0x88,
    0x99, 0x99, 0x99, 0x99, 0x3a, 0xaa, 0xaa, 0xaa, 0x3a, 0xaa, 0xaa, 0xaa, 0x3a, 0xaa, 0xaa, 0xaa,
    0x3a, 0xaa, 0xaa, 0xaa, 0x3a, 0xaa, 0xaa, 0xaa, 0x77, 0x77, 0x77, 0x79, 0x88, 0x77, 0x77, 0x99,
    0x99, 0x99, 0x99, 0x99, 0x99, 0xaa, 0xaa, 0xaa, 0x93, 0xaa, 0xaa, 0xaa, 0x93, 0xaa, 0xaa, 0xaa,
    0x93, 0xaa, 0xa7, 0x77, 0x93, 0xaa, 0xa9, 0x99, 0x93, 0xaa, 0xa9, 0x99, 0x93, 0x77, 0x79, 0x9a,
    0x99, 0x99, 0x99, 0x99, 0xaa, 0x99, 0x9a, 0xaa, 0xaa, 0x99, 0x3a, 0xaa, 0xaa, 0x99, 0x3a, 0xaa,
    0x77, 0x99, 0x77, 0x79, 0x99, 0x99, 0x99, 0x99, 0xaa, 0xaa, 0xaa, 0xa9, 0xaa, 0xaa, 0xaa, 0xaa,
    0x99, 0x99, 0x99, 0x99, 0x99, 0x93, 0xaa, 0xa9, 0x99, 0x93, 0xad, 0xa9, 0x99, 0x93, 0xaa, 0xa9,
    0x99, 0x93, 0xad, 0xa9, 0x99, 0x93, 0xaa, 0xa9, 0x99, 0x93, 0xad, 0xa9, 0x99, 0x93, 0xaa, 0xa9,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0x99, 0x99, 0x99, 0x99, 0x99, 0x91, 0x66, 0x66, 0x99, 0x11, 0x66, 0x66, 0x91, 0x11, 0x66, 0x66,
    0x91, 0x11, 0x66, 0x66, 0x91, 0x11, 0x66, 0x66, 0x91, 0x11, 0x66, 0x66, 0x91, 0x11, 0x6a, 0xaa,
    0x99, 0x99, 0x99, 0x99, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
    0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0xaa, 0xaa, 0xaa, 0xaa,
    0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99,
    0x99, 0x99, 0x99, 0x99, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0xaa, 0xaa, 0xaa, 0x66,
    0x99, 0x99, 0x99, 0x99, 0x99, 0x49, 0x99, 0x98, 0x99, 0x99, 0x99, 0x98, 0x99, 0x99, 0x99, 0x88,
    0x99, 0x99, 0x98, 0x88, 0x99, 0x98, 0x88, 0x88, 0x99, 0x88, 0x88, 0x88, 0x98, 0x88, 0x88, 0x88,
    0x99, 0x33, 0x33, 0x33, 0x93, 0x33, 0x03, 0x03, 0x93, 0x33, 0x33, 0x33, 0x93, 0x03, 0x03, 0x03,
    0x93, 0x33, 0x33, 0x33, 0x93, 0x03, 0x03, 0x03, 0x93, 0x33, 0x33, 0x33, 0x93, 0x03, 0x03, 0x33,
    0x33, 0xaa, 0xaa, 0xab, 0x03, 0xaa, 0xaa, 0xab, 0x33, 0xaa, 0xaa, 0xa5, 0x03, 0xaa, 0xaa, 0xaa,
    0x33, 0xaa, 0xaa, 0xaa, 0x33, 0xaa, 0xaa, 0xaa, 0x37, 0x77, 0x77, 0x77, 0x77, 0x73, 0x73, 0x73,
    0x55, 0xba, 0xaa, 0xaa, 0xaa, 0xba, 0xaa, 0xaa, 0xaa, 0x5a, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa,
    0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0x77, 0x77, 0x77, 0x79, 0x73, 0x73, 0x77, 0x99,
    0x93, 0x03, 0x03, 0x38, 0x93, 0x33, 0x33, 0x38, 0x93, 0x03, 0x03, 0x38, 0x93, 0x33, 0x33, 0x38,
    0x93, 0x03, 0x03, 0x38, 0x93, 0x33, 0x33, 0x38, 0x93, 0x03, 0x03, 0x38, 0x93, 0x33, 0x33, 0x38,
    0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xad, 0xda, 0xaa, 0xaa, 0xd8, 0x8d, 0xaa, 0xaa, 0xda, 0xa8, 0xaa,
    0xaa, 0xda, 0xaa, 0xaa, 0xaa, 0xda, 0xad, 0xaa, 0xaa, 0x8d, 0xd8, 0xaa, 0xaa, 0xa8, 0x8a, 0xaa,
    0xa8, 0xaa, 0xaa, 0x99, 0xa8, 0xaa, 0xaa, 0x99, 0xa8, 0xaa, 0xaa, 0x99, 0xa8, 0xaa, 0xaa, 0x99,
    0xa8, 0xaa, 0xaa, 0xaa, 0xa8, 0xaa, 0xaa, 0xaa, 0xa8, 0xaa, 0xaa, 0xaa, 0xa8, 0xaa, 0xaa, 0xaa,
    0x99, 0x99, 0x99, 0xaa, 0x99, 0x99, 0x9a, 0xaa, 0x99, 0x99, 0x3a, 0xaa, 0x99, 0x93, 0x3a, 0xaa,
    0x99, 0x93, 0x3a, 0xaa, 0x99, 0x93, 0x3a, 0xaa, 0x99, 0x93, 0x3a, 0xaa, 0x99, 0x93, 0x3a, 0xaa,
    0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xee, 0xea, 0xaa, 0xaa, 0x4e, 0x4a, 0xaa, 0xaa, 0xae, 0xaa, 0xaa,
    0xaa, 0xae, 0xaa, 0xaa, 0xaa, 0xae, 0xaa, 0xaa, 0xaa, 0xee, 0xea, 0xaa, 0xaa, 0x44, 0x4a, 0xaa,
    0xa9, 0x93, 0x77, 0x79, 0xaa, 0x99, 0x99, 0x99, 0xaa, 0x99, 0xdd, 0x99, 0xaa, 0x93, 0xaa, 0xd9,
    0xaa, 0x93, 0xaa, 0xd9, 0xaa, 0x99, 0x77, 0x99, 0xaa, 0x93, 0xaa, 0xd9, 0xaa, 0x93, 0xaa, 0xd9,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0x91, 0x11, 0x1a, 0x66, 0x91, 0x11, 0x1a, 0x66, 0x91, 0x11, 0x1a, 0x66, 0x91, 0x10, 0x1a, 0x66,
    0x91, 0x11, 0x1a, 0x66, 0x91, 0x10, 0x1a, 0x66, 0x91, 0x11, 0x1a, 0x66, 0x91, 0x10, 0x1a, 0x66,
    0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x6f, 0xff, 0xf6, 0xff, 0x6f, 0x11, 0x16, 0xf1,
    0x6f, 0x66, 0x66, 0xf6, 0x6f, 0xff, 0x66, 0xf6, 0x6f, 0x11, 0x66, 0xf6, 0x6f, 0x66, 0x66, 0xff,
    0x66, 0x66, 0x6a, 0x66, 0x66, 0x66, 0x6a, 0x66, 0xf6, 0x66, 0x6a, 0x66, 0x1f, 0x66, 0x6a, 0x66,
    0x6f, 0x66, 0x6a, 0x66, 0x6f, 0x66, 0x6a, 0x66, 0x6f, 0x66, 0x6a, 0x66, 0xf1, 0x66, 0x6a, 0x66,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0x93, 0x33, 0x33, 0x37, 0x93, 0x03, 0x33, 0x77, 0x93, 0x33, 0x37, 0x77, 0x93, 0x33, 0x77, 0x73,
    0x93, 0x37, 0x77, 0x77, 0x93, 0x77, 0x73, 0x73, 0x97, 0x77, 0x77, 0x77, 0x99, 0x99, 0x99, 0x99,
    0x77, 0x77, 0x77, 0x77, 0x73, 0x73, 0x73, 0x73, 0x77, 0x77, 0x77, 0x77, 0x73, 0x73, 0x73, 0x73,
    0x77, 0x77, 0x77, 0x77, 0x73, 0x73, 0x73, 0x77, 0x77, 0x77, 0x77, 0x79, 0x99, 0x99, 0x99, 0x99,
    0x77, 0x77, 0x75, 0x55, 0x73, 0x77, 0x55, 0x55, 0x77, 0x75, 0x55, 0x55, 0x77, 0xbb, 0xbb, 0xbb,
    0x7b, 0xbb, 0xbb, 0xbb, 0x9b, 0xbb, 0xbb, 0xbb, 0x9b, 0xbb, 0xbb, 0xbb, 0x99, 0x99, 0x99, 0x99,
    0x93, 0x03, 0x03, 0x38, 0x93, 0x33, 0x33, 0x38, 0x93, 0x03, 0x03, 0x37, 0x93, 0x33, 0x33, 0x77,
    0x93, 0x03, 0x37, 0x77, 0x93, 0x33, 0x77, 0x37, 0x93, 0x37, 0x77, 0x77, 0x93, 0x77, 0x37, 0x37,
    0xaa, 0xaa, 0xaa, 0xaa, 0x88, 0x88, 0x88, 0x88, 0x77, 0x77, 0x77, 0x77, 0x37, 0x37, 0x37, 0x37,
    0x77, 0x77, 0x77, 0x77, 0x37, 0x37, 0x37, 0x37, 0x77, 0x77, 0x77, 0x77, 0x37, 0x37, 0x37, 0x37,
    0xa8, 0xaa, 0xaa, 0xaa, 0x88, 0xaa, 0xaa, 0xaa, 0x7a, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa,
    0x77, 0x77, 0x77, 0x77, 0x37, 0x37, 0x37, 0x79, 0x77, 0x77, 0x77, 0x99, 0x37, 0x37, 0x79, 0x99,
    0x99, 0x93, 0x33, 0xaa, 0x99, 0x93, 0x33, 0x3a, 0x99, 0x99, 0x33, 0x77, 0x99, 0x99, 0x97, 0x77,
    0x99, 0xaa, 0x99, 0x77, 0x93, 0xaa, 0xa9, 0x99, 0x93, 0xaa, 0xa9, 0x99, 0x99, 0x77, 0x99, 0x99,
    0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xaa, 0xa9, 0x77, 0x77, 0x77, 0x99,
    0x77, 0x77, 0x79, 0x93, 0x99, 0x99, 0x99, 0x93, 0x99, 0x99, 0x99, 0x93, 0x99, 0x99, 0x99, 0x93,
    0xa9, 0x99, 0x77, 0x99, 0x99, 0x93, 0xaa, 0xd9, 0x99, 0x93, 0xaa, 0xd9, 0xaa, 0x99, 0x77, 0x99,
    0xaa, 0x99, 0x99, 0x99, 0xaa, 0xaa, 0xaa, 0xa9, 0xaa, 0xaa, 0xaa, 0xa9, 0x77, 0x77, 0x77, 0x99,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0x91, 0x11, 0x1a, 0x66, 0x91, 0x10, 0x1a, 0x66, 0x91, 0x11, 0x1a, 0x66, 0x91, 0x10, 0x1a, 0xaa,
    0x91, 0x11, 0x16, 0x66, 0x91, 0x11, 0x66, 0x60, 0x91, 0x16, 0x66, 0x00, 0x91, 0x66, 0x60, 0x00,
    0x61, 0x66, 0x66, 0x11, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0xaa, 0xaa, 0xaa, 0xaa,
    0x66, 0x66, 0x66, 0x66, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x06,
    0x16, 0x66, 0x6a, 0x66, 0x66, 0x66, 0x6a, 0x66, 0x66, 0x66, 0x6a, 0x66, 0xaa, 0xaa, 0xaa, 0x66,
    0x66, 0x66, 0xa6, 0x66, 0x06, 0x6a, 0xaa, 0xaa, 0x66, 0x66, 0x66, 0x69, 0x66, 0x66, 0x66, 0x99,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0x99, 0x99, 0x99, 0x99, 0x99, 0xaa, 0xaa, 0xaa, 0x93, 0xaa, 0xaa, 0xaa, 0x93, 0xaa, 0xaa, 0xa0,
    0x93, 0xaa, 0xaa, 0xa0, 0x93, 0xaa, 0xaa, 0x30, 0x93, 0xaa, 0xaa, 0x30, 0x93, 0xaa, 0xa3, 0x30,
    0x99, 0x00, 0x00, 0x00, 0xa0, 0xaa, 0xaa, 0xaa, 0x0a, 0xa3, 0x33, 0x3a, 0xaa, 0x33, 0x33, 0x33,
    0xa3, 0x33, 0x33, 0x33, 0xa3, 0x33, 0x33, 0x33, 0xa3, 0x33, 0x33, 0x33, 0xa3, 0x33, 0x33, 0x33,
    0x99, 0x99, 0x99, 0x90, 0x0a, 0xaa, 0xaa, 0x0a, 0xa0, 0xaa, 0xa0, 0xaa, 0xaa, 0x0a, 0x0a, 0xa3,
    0x3a, 0x00, 0x0a, 0x33, 0x3a, 0x03, 0x0a, 0x33, 0x3a, 0x03, 0x0a, 0x33, 0x3a, 0x03, 0x0a, 0x33,
    0x00, 0x00, 0x09, 0x99, 0xaa, 0xaa, 0xa0, 0x99, 0x33, 0x33, 0xaa, 0x09, 0x33, 0x33, 0x3a, 0xa0,
    0x33, 0x33, 0x33, 0xa0, 0x33, 0x33, 0x33, 0xa0, 0x33, 0x33, 0x33, 0xa0, 0x33, 0x33, 0x33, 0xa0,
    0x99, 0x99, 0x99, 0x99, 0x93, 0x33, 0x33, 0x33, 0x93, 0x33, 0x33, 0x33, 0x9a, 0xaa, 0xaa, 0xdd,
    0x9a, 0xaa, 0xaa, 0xdd, 0x9a, 0xaa, 0xaa, 0xdd, 0x97, 0x77, 0x77, 0x77, 0x97, 0x77, 0x77, 0x77,
    0x99, 0x99, 0x99, 0x99, 0x33, 0x99, 0x33, 0x33, 0x33, 0x93, 0xaa, 0xaa, 0xaa, 0x3a, 0xa7, 0x77,
    0xa3, 0xaa, 0xaa, 0xaa, 0xa3, 0xa7, 0xa3, 0x33, 0x73, 0xa7, 0xa3, 0xff, 0x73, 0xaa, 0xa3, 0xfb,
    0x99, 0x99, 0x99, 0x99, 0x33, 0x33, 0x33, 0x33, 0xaa, 0xaa, 0xaa, 0xaa, 0xa7, 0x77, 0xa7, 0x77,
    0xaa, 0xaa, 0xaa, 0xaa, 0x33, 0x33, 0x33, 0x33, 0xff, 0xff, 0xff, 0xff, 0xbf, 0xbb, 0xbb, 0xbf,
    0x99, 0x99, 0x99, 0x99, 0x33, 0x33, 0x39, 0x99, 0xaa, 0xaa, 0xa3, 0x99, 0xa7, 0x77, 0xaa, 0x39,
    0xaa, 0xaa, 0xaa, 0xa3, 0x33, 0x33, 0xa7, 0xa3, 0xff, 0xf3, 0xa7, 0xa3, 0xbb, 0xf3, 0xaa, 0xa3,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0x93, 0xaa, 0x33, 0x30, 0x93, 0xaa, 0x33, 0x30, 0x93, 0xaa, 0x33, 0x33, 0x93, 0xaa, 0x33, 0x73,
    0x93, 0xaa, 0x37, 0x37, 0x93, 0xaa, 0x33, 0x73, 0x93, 0xaa, 0xa7, 0x37, 0x93, 0x3a, 0xaa, 0x77,
    0xa3, 0x33, 0x33, 0x33, 0xaa, 0x33, 0x33, 0x33, 0x0a, 0xa3, 0x33, 0x3a, 0x70, 0xaa, 0xaa, 0xaa,
    0x37, 0x00, 0x00, 0x00, 0x77, 0x77, 0x77, 0x7a, 0x77, 0x77, 0x77, 0xaa, 0x77, 0x77, 0x7a, 0xaa,
    0x3a, 0x03, 0x0a, 0x33, 0xaa, 0x03, 0x0a, 0xa3, 0xa0, 0x33, 0x30, 0xaa, 0x03, 0x33, 0x33, 0x0a,
    0x03, 0x33, 0x73, 0x70, 0xa3, 0x37, 0x37, 0x77, 0xaa, 0x33, 0x73, 0x77, 0xaa, 0xa7, 0x77, 0x77,
    0x33, 0x33, 0x33, 0xa0, 0x33, 0x33, 0x3a, 0xa0, 0x33, 0x33, 0xaa, 0x09, 0xaa, 0xaa, 0xa0, 0x99,
    0x00, 0x00, 0x0a, 0x99, 0x77, 0x7a, 0xaa, 0x99, 0x77, 0xaa, 0xaa, 0x99, 0x7a, 0xaa, 0xaa, 0x99,
    0xff, 0xff, 0xff, 0xff, 0xf7, 0x77, 0x77, 0x77, 0xf7, 0xf7, 0xf7, 0xf7, 0xf7, 0x77, 0x77, 0x77,
    0xf7, 0x77, 0x77, 0x77, 0xf7, 0xf7, 0xf7, 0xf7, 0xf7, 0x77, 0x77, 0x77, 0xf7, 0x77, 0x77, 0x77,
    0xf3, 0xa7, 0xa3, 0xfb, 0xf3, 0xa7, 0xa3, 0xfb, 0xf3, 0xaa, 0xa3, 0xfb, 0xf3, 0xa7, 0xa3, 0xfb,
    0xf3, 0xa7, 0xa3, 0xfb, 0xf3, 0xaa, 0xa3, 0xfb, 0xf3, 0xa7, 0xa3, 0xfb, 0xf3, 0xa7, 0xa3, 0xfb,
    0xbf, 0xbb, 0xbb, 0xbf, 0xbf, 0xff, 0xff, 0xff, 0xbb, 0xbb, 0xbb, 0xbb, 0xbb, 0xbb, 0xbb, 0xbb,
    0xbb, 0xbb, 0xbb, 0xbb, 0xbb, 0xbb, 0xbb, 0xbb, 0xbb, 0xbf, 0xff, 0xbb, 0xbb, 0xfb, 0xbb, 0xfb,
    0xbb, 0xf3, 0xa7, 0xa3, 0xbb, 0xf3, 0xa7, 0xa3, 0xbb, 0xf3, 0xaa, 0xa3, 0xbb, 0xf3, 0xa7, 0xa3,
    0xbb, 0xf3, 0xa7, 0xa3, 0xbb, 0xf3, 0xaa, 0xa3, 0xbb, 0xf3, 0xa7, 0xa3, 0xbb, 0xf3, 0xa7, 0xa3,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0x99, 0x3a, 0xaa, 0xad, 0x99, 0x3a, 0xaa, 0x3d, 0x99, 0x3a, 0xa3, 0x3d, 0x99, 0x3a, 0x30, 0x3d,
    0x99, 0x33, 0x33, 0x3d, 0x99, 0x33, 0x30, 0x3d, 0x99, 0x33, 0x33, 0x3d, 0x99, 0x33, 0x30, 0x3d,
    0xdd, 0xdd, 0xdd, 0xdd, 0xaa, 0xa6, 0x66, 0x6a, 0xaa, 0x66, 0x6e, 0x66, 0xa6, 0x66, 0xee, 0x66,
    0xa6, 0x6e, 0xe6, 0x66, 0xa6, 0x6e, 0xee, 0xee, 0xa6, 0x66, 0x6e, 0xe6, 0xaa, 0x66, 0xee, 0x66,
    0xdd, 0xdd, 0x77, 0x77, 0xaa, 0xad, 0xaa, 0xaa, 0xaa, 0xad, 0xaa, 0xaa, 0x6a, 0xad, 0x33, 0x3a,
    0x6a, 0xad, 0xee, 0xe3, 0x6a, 0xad, 0xe9, 0xe3, 0x6a, 0xad, 0xee, 0xe3, 0xaa, 0xad, 0x77, 0x7a,
    0xaa, 0xaa, 0xaa, 0xa9, 0xaa, 0xaa, 0xaa, 0xa9, 0xaa, 0xaa, 0xaa, 0xa9, 0xaa, 0x33, 0x3a, 0xa9,
    0xa3, 0xee, 0xe3, 0xa9, 0xa3, 0xe9, 0xe3, 0xa9, 0xa3, 0xee, 0xe3, 0xa9, 0xaa, 0x77, 0x7a, 0xa9,
    0xf7, 0x77, 0x77, 0x77, 0xf7, 0xf7, 0xf7, 0xf7, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
    0x77, 0x77, 0x77, 0x77, 0xf7, 0xf7, 0xf7, 0xf7, 0xf7, 0x77, 0x77, 0x77, 0xaa, 0xaa, 0xa7, 0x7f,
    0xf3, 0xaa, 0xa3, 0xff, 0xf3, 0xa7, 0xa3, 0xfb, 0xf3, 0xa7, 0xa3, 0xfb, 0xf3, 0xaa, 0xa3, 0xfb,
    0xf3, 0xa7, 0xa3, 0xfb, 0xf3, 0xa7, 0xa3, 0xfb, 0xf3, 0xaa, 0xa3, 0xfb, 0xf3, 0xa7, 0xa3, 0xfb,
    0xff, 0xff, 0xff, 0xff, 0xbb, 0xfb, 0xbb, 0xfb, 0xbb, 0xbf, 0xff, 0xbb, 0xbb, 0xbb, 0xbb, 0xbb,
    0xbb, 0xbb, 0xbb, 0xbb, 0xbb, 0xbb, 0xbb, 0xbb, 0xbb, 0xbb, 0xbb, 0xbb, 0xbf, 0xff, 0xff, 0xff,
    0xff, 0xf3, 0xaa, 0xa3, 0xbb, 0xf3, 0xa7, 0xa3, 0xbb, 0xf3, 0xa7, 0xa3, 0xbb, 0xf3, 0xaa, 0xa3,
    0xbb, 0xf3, 0xa7, 0xa3, 0xbb, 0xf3, 0xa7, 0xa3, 0xbb, 0xf3, 0xaa, 0xa3, 0xbb, 0xf3, 0xa7, 0xa3,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0x99, 0x33, 0x33, 0x3d, 0x99, 0x33, 0x33, 0x3d, 0x99, 0x33, 0x33, 0x77, 0x99, 0x33, 0x37, 0x77,
    0x99, 0x33, 0x77, 0x77, 0x99, 0x37, 0x77, 0x77, 0x99, 0x3a, 0xaa, 0xaa, 0x99, 0x77, 0x77, 0x77,
    0xaa, 0xa6, 0x66, 0x6a, 0xdd, 0xdd, 0xdd, 0xdd, 0x77, 0x77, 0x77, 0x77, 0x37, 0x37, 0x33, 0x73,
    0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0xaa, 0xaa, 0xaa, 0xaa, 0x77, 0x77, 0x77, 0x77,
    0xaa, 0xad, 0xaa, 0xaa, 0xdd, 0xdd, 0x33, 0x3a, 0x77, 0x73, 0xee, 0xe3, 0x73, 0x73, 0xe9, 0xe3,
    0x77, 0xa3, 0xee, 0xe3, 0x7a, 0xaa, 0x77, 0x7a, 0xaa, 0xaa, 0xaa, 0xaa, 0x77, 0x77, 0x77, 0x77,
    0xaa, 0xaa, 0xaa, 0xa9, 0xaa, 0x33, 0x3a, 0xa9, 0xa3, 0xee, 0xe3, 0xa9, 0xa3, 0xe9, 0xe3, 0xa9,
    0xa3, 0xee, 0xe3, 0xa9, 0xaa, 0x77, 0x7a, 0xa9, 0xaa, 0xaa, 0xaa, 0xa9, 0x77, 0x77, 0x77, 0x79,
    0xa8, 0x88, 0xa7, 0x77, 0xa8, 0xa8, 0xa7, 0x77, 0xa8, 0xa8, 0xaa, 0xaa, 0xa8, 0xa8, 0x88, 0x88,
    0xa8, 0xaa, 0xaa, 0xa8, 0xa8, 0x88, 0x88, 0x88, 0xaa, 0xaa, 0xaa, 0xaa, 0x77, 0x77, 0x77, 0x77,
    0x73, 0xa7, 0xa3, 0xfb, 0x73, 0xaa, 0xa3, 0xfb, 0xa3, 0xa7, 0xa3, 0xff, 0xa3, 0xa7, 0xa3, 0x33,
    0xa3, 0xaa, 0xaa, 0xaa, 0xa9, 0x3a, 0xa7, 0x77, 0xa9, 0x93, 0xaa, 0xaa, 0x79, 0x99, 0x33, 0x33,
    0xbf, 0xbb, 0xbb, 0xbf, 0xbf, 0xbb, 0xbb, 0xbf, 0xff, 0xff, 0xff, 0xff, 0x33, 0x33, 0x33, 0x33,
    0xaa, 0xaa, 0xaa, 0xaa, 0xa7, 0x77, 0xa7, 0x77, 0xaa, 0xaa, 0xaa, 0xaa, 0x33, 0x33, 0x33, 0x33,
    0xbb, 0xf3, 0xa7, 0xa3, 0xbb, 0xf3, 0xaa, 0xa3, 0xff, 0xf3, 0xa7, 0xa3, 0x33, 0x33, 0xa7, 0xa3,
    0xaa, 0xaa, 0xaa, 0xa3, 0xa7, 0x77, 0xaa, 0x39, 0xaa, 0xaa, 0xa3, 0x99, 0x33, 0x33, 0x39, 0x99,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0x99, 0x99, 0xaa, 0xa9, 0x93, 0xa3, 0xaa, 0xaa, 0x93, 0xa3, 0x77, 0x7a, 0x93, 0xaa, 0xaa, 0xaa,
    0x93, 0x77, 0x77, 0xaa, 0x93, 0xaa, 0xa7, 0xaa, 0x93, 0xaa, 0xa7, 0x77, 0x97, 0x77, 0x77, 0x77,
    0x99, 0x93, 0x39, 0x99, 0x98, 0x88, 0x88, 0x89, 0x9d, 0xdd, 0xdd, 0xd9, 0x9d, 0xdd, 0xdd, 0xd9,
    0x97, 0x77, 0x77, 0x79, 0x97, 0x77, 0x77, 0x73, 0x99, 0x99, 0xaa, 0xaa, 0x99, 0x99, 0x77, 0x77,
    0x99, 0x99, 0x99, 0x99, 0x3a, 0xaa, 0xaa, 0xaa, 0x3a, 0xaa, 0xaf, 0xfa, 0x3a, 0xaa, 0xa7, 0x7a,
    0x77, 0x77, 0xaa, 0xaa, 0x99, 0x99, 0xaa, 0xaa, 0x00, 0x99, 0xaa, 0xaa, 0x00, 0x99, 0x77, 0x77,
    0x9a, 0xaa, 0xaa, 0xaa, 0x9a, 0xdd, 0xad, 0xda, 0x9a, 0x33, 0xa3, 0x3a, 0x9a, 0xaa, 0xaa, 0xaa,
    0x9a, 0xdd, 0xad, 0xda, 0x9a, 0x33, 0xa3, 0x3a, 0x97, 0x77, 0x77, 0x77, 0x99, 0x99, 0x99, 0x99,
    0x99, 0x99, 0x99, 0x99, 0x3a, 0xa3, 0xaa, 0xaa, 0x3a, 0xa3, 0xaa, 0xaa, 0x3a, 0xa3, 0xa7, 0x77,
    0x3a, 0xa3, 0xa9, 0x99, 0x3a, 0xa3, 0xaa, 0xaa, 0x3a, 0xa3, 0xaa, 0xaa, 0x77, 0x77, 0x77, 0x77,
    0x99, 0x99, 0x9a, 0xaa, 0x93, 0xaa, 0xaf, 0xaa, 0x93, 0xaa, 0xaf, 0xaa, 0x93, 0xaa, 0xaf, 0xaa,
    0x93, 0xaa, 0xaf, 0xaa, 0x93, 0x77, 0x77, 0xaa, 0x99, 0x3a, 0xaa, 0xaa, 0x99, 0x37, 0x77, 0x77,
    0x99, 0x99, 0xaa, 0xaa, 0x99, 0x99, 0xad, 0xda, 0x99, 0x99, 0x77, 0x77, 0xaa, 0xaa, 0xaa, 0x99,
    0xaa, 0xaa, 0xaa, 0x99, 0x3d, 0xd3, 0xdd, 0x99, 0xaa, 0xaa, 0xaa, 0x99, 0x77, 0x77, 0x77, 0x99,
    0x93, 0x8d, 0x3a, 0xaa, 0x93, 0x8d, 0x3a, 0xaa, 0x93, 0x8d, 0x3a, 0xaa, 0x93, 0x8d, 0x3a, 0xaa,
    0x93, 0x8d, 0x3a, 0xaa, 0x97, 0x77, 0x77, 0x77, 0x99, 0x3a, 0xaa, 0x99, 0x99, 0x37, 0x77, 0x99,
    0x99, 0x99, 0x96, 0x99, 0x99, 0x99, 0x6e, 0x69, 0x99, 0x96, 0xee, 0x69, 0x99, 0x6e, 0xee, 0x69,
    0x96, 0xee, 0xee, 0x69, 0x96, 0xee, 0x9e, 0x69, 0x96, 0xe9, 0x9e, 0x69, 0x99, 0x66, 0x66, 0x99,
    0x99, 0x99, 0x69, 0x99, 0x99, 0x96, 0xe6, 0x99, 0x99, 0x6e, 0xe6, 0x99, 0x99, 0x6e, 0xee, 0x69,
    0x99, 0x6e, 0xee, 0x69, 0x96, 0xee, 0x9e, 0x69, 0x96, 0xe9, 0x9e, 0x69, 0x99, 0x66, 0x66, 0x99,
    0x99, 0x99, 0x99, 0x99, 0x99, 0x69, 0x99, 0x99, 0x96, 0xe6, 0x69, 0x99, 0x96, 0xee, 0xe6, 0x99,
    0x96, 0xee, 0xee, 0x69, 0x96, 0xe9, 0xee, 0x69, 0x96, 0xe9, 0x9e, 0x69, 0x99, 0x66, 0x66, 0x99,
    0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x96, 0x96, 0x69, 0x99, 0x6e, 0x6e, 0x69,
    0x99, 0x6e, 0xee, 0x69, 0x96, 0xee, 0xee, 0xe6, 0x96, 0xe9, 0x9e, 0x66, 0x99, 0x66, 0x66, 0x99,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x00, 0x0f, 0xff, 0xff, 0x0f, 0x0f, 0xf0,
    0xff, 0x00, 0x00, 0x0f, 0xf0, 0xff, 0xff, 0x0f, 0xff, 0x00, 0x00, 0xf0, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0x0f, 0xff, 0xff, 0xf0, 0xf0, 0xff, 0xff, 0xf0, 0x00, 0xff, 0xff, 0x00, 0xf0, 0x0f,
    0xff, 0x00, 0x00, 0x0f, 0xf0, 0x00, 0xf0, 0x00, 0xf0, 0x00, 0xf0, 0x00, 0xf0, 0x00, 0x00, 0x00,
    0xff, 0xff, 0x0f, 0xff, 0xff, 0x00, 0x00, 0x0f, 0xff, 0xff, 0x0f, 0xff, 0xff, 0x00, 0x00, 0x0f,
    0xff, 0xff, 0x0f, 0xff, 0xff, 0xff, 0x0f, 0xff, 0xff, 0xff, 0x0f, 0xff, 0xff, 0xff, 0x0f, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x0f, 0xff, 0xff, 0xf0, 0x00, 0xff, 0xff, 0x00, 0x00, 0x0f,
    0xf0, 0x00, 0x00, 0x00, 0xff, 0x00, 0x0f, 0x0f, 0xff, 0x0f, 0x00, 0x0f, 0xff, 0x0f, 0x00, 0x0f,
    0xff, 0x00, 0x00, 0x0f, 0xff, 0x0f, 0x0f, 0x0f, 0xff, 0x00, 0x00, 0x0f, 0xff, 0x0f, 0x0f, 0x0f,
    0xff, 0x00, 0x00, 0x0f, 0xff, 0x0f, 0x0f, 0x0f, 0xff, 0x00, 0x00, 0x0f, 0xff, 0x00, 0xf0, 0x0f,
    0xff, 0xf0, 0xf0, 0xff, 0xff, 0x0f, 0x0f, 0xff, 0xf0, 0xf0, 0xff, 0xff, 0xf0, 0xf0, 0xff, 0xff,
    0xf0, 0xf0, 0xff, 0xff, 0xf0, 0x00, 0x00, 0x00, 0xf0, 0x00, 0x00, 0x00, 0xf0, 0x00, 0x00, 0x00,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x0f, 0xff, 0xff, 0xf0, 0x0f, 0xff, 0xff, 0x00, 0xff, 0xff,
    0xff, 0x00, 0x00, 0x0f, 0xff, 0xff, 0x00, 0xff, 0xff, 0xf0, 0x0f, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0x00, 0x0f, 0xff, 0xf0, 0x0f, 0x00, 0xff, 0xf0, 0xf0, 0xf0, 0xff,
    0xff, 0x0f, 0x0f, 0xff, 0xff, 0xf0, 0xff, 0xff, 0xff, 0xf0, 0xff, 0xff, 0xff, 0xf0, 0xff, 0xff,
    0xf0, 0xff, 0xff, 0x0f, 0xf0, 0x0f, 0xf0, 0x0f, 0xf0, 0x00, 0x0f, 0x0f, 0xf0, 0x00, 0xf0, 0x0f,
    0xf0, 0x0f, 0x00, 0x0f, 0xf0, 0xf0, 0x00, 0x0f, 0xff, 0x00, 0x00, 0xff, 0xff, 0xf0, 0x0f, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0x00, 0x0f, 0xff, 0xff, 0xf0, 0xf0, 0xff, 0xff, 0x00, 0x0f, 0x0f,
    0xff, 0x00, 0x0f, 0x0f, 0xff, 0x00, 0x00, 0xff, 0xff, 0x00, 0x0f, 0xff, 0xff, 0x00, 0x0f, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xf0, 0x0f, 0xff, 0xff, 0x0f, 0x00, 0xff,
    0xf0, 0xff, 0x00, 0x0f, 0xf0, 0x00, 0xff, 0x0f, 0xff, 0x00, 0xf0, 0xff, 0xff, 0xf0, 0x0f, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x0f, 0xff, 0xff, 0xf0, 0x00, 0x0f, 0xff, 0x0f, 0x0f, 0xff,
    0xff, 0xf0, 0x00, 0xff, 0xff, 0xff, 0x0f, 0x0f, 0xff, 0x00, 0x00, 0xff, 0xff, 0xff, 0x0f, 0xff,
    0x00, 0xff, 0x0f, 0x0f, 0x00, 0xff, 0x0f, 0x00, 0x00, 0xff, 0xff, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x0f, 0xff, 0xff, 0xf0, 0x0f, 0xff, 0xff, 0xf0, 0x0f, 0xff, 0xff, 0xf0, 0x00, 0x00, 0x00, 0x00,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
};
#else
const uint8_t TileImageData[] PROGMEM =
{
// 128, 128
// 0
0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
0xff, 0xff, 0xdd, 0xff, 0xff, 0xff, 0xef, 0xff, 
0xff, 0xfd, 0xff, 0xdf, 0xff, 0xfb, 0xff, 0xff, 
0xff, 0xff, 0xfd, 0xff, 0xbf, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xf7, 0xff, 0xbf, 0xfd, 0xff, 
0x01, 0x11, 0x11, 0x01, 0x01, 0x11, 0x11, 0x01, 
0xff, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 
0xff, 0x07, 0x03, 0x01, 0x61, 0x11, 0x11, 0x01, 
0x01, 0x11, 0x11, 0x01, 0x61, 0x01, 0x03, 0x07, 
0x01, 0x10, 0x10, 0x00, 0x06, 0x00, 0x80, 0xc0, 
0xff, 0xc0, 0x80, 0x00, 0x06, 0x10, 0x10, 0x00, 
0x01, 0x11, 0x11, 0x01, 0x81, 0x11, 0x91, 0x01, 
0x51, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 
0x01, 0x10, 0x11, 0x00, 0x01, 0x10, 0x10, 0x00, 
0xff, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x14, 
0x51, 0x00, 0x01, 0x00, 0x81, 0x00, 0x80, 0x14, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0x88, 0x88, 0x82, 0x22, 0x20, 0x00, 0x08, 0x88, 
0x88, 0x80, 0xa2, 0x22, 0x20, 0x20, 0x00, 0x88, 
0x88, 0x82, 0x22, 0x22, 0x22, 0x20, 0x00, 0x08, 
0x88, 0x8a, 0x02, 0x22, 0x22, 0x00, 0x08, 0x08, 
0x41, 0x15, 0x51, 0x05, 0x41, 0x15, 0x51, 0x05, 
0xff, 0x00, 0x55, 0x00, 0x66, 0x00, 0xaa, 0x00, 
0xff, 0x07, 0x43, 0x09, 0x61, 0x15, 0x91, 0x05, 
0x41, 0x15, 0x51, 0x05, 0x61, 0x09, 0xa3, 0x07, 
0x41, 0x14, 0x51, 0x00, 0x26, 0x00, 0x8a, 0xc0, 
0xff, 0xc0, 0x95, 0x00, 0x46, 0x10, 0x52, 0x00, 
0x41, 0x15, 0x51, 0x05, 0xc1, 0x15, 0xd1, 0x05, 
0x51, 0x00, 0x55, 0x00, 0x66, 0x00, 0xaa, 0x00, 
0x41, 0x14, 0x51, 0x04, 0x41, 0x14, 0x50, 0x04, 
0xff, 0x00, 0x55, 0x00, 0x66, 0x00, 0xaa, 0x14, 
0x51, 0x04, 0x41, 0x00, 0x81, 0x00, 0x84, 0x14, 
0x82, 0x92, 0x92, 0x82, 0x82, 0x92, 0x92, 0x82, 
0x00, 0xff, 0x00, 0x00, 0x66, 0x00, 0x00, 0xff, 
0x8a, 0x8a, 0x0a, 0x0a, 0x2a, 0x2a, 0x0a, 0x0a, 
0x88, 0x80, 0x00, 0xff, 0x00, 0xff, 0x00, 0x08, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0x05, 0x51, 0x15, 0x41, 0x05, 0x51, 0x15, 0x41, 
0xff, 0x00, 0xaa, 0x00, 0x66, 0x00, 0x55, 0x00, 
0xff, 0x07, 0x93, 0x01, 0x65, 0x11, 0x15, 0x01, 
0x05, 0x51, 0x95, 0x01, 0x65, 0x01, 0x53, 0x07, 
0x05, 0x50, 0x12, 0x40, 0x06, 0x10, 0x85, 0xc0, 
0xff, 0xc0, 0x8a, 0x20, 0x06, 0x50, 0x11, 0x40, 
0x05, 0x51, 0x15, 0x41, 0x85, 0x51, 0x95, 0x41, 
0x51, 0x00, 0xaa, 0x00, 0x66, 0x00, 0x55, 0x00, 
0x05, 0x50, 0x15, 0x40, 0x05, 0x50, 0x14, 0x40, 
0xff, 0x00, 0xaa, 0x00, 0x66, 0x00, 0x55, 0x14, 
0x51, 0x40, 0x03, 0x00, 0x81, 0x02, 0x80, 0x14, 
0x00, 0x7e, 0x66, 0x2a, 0x4c, 0x6e, 0x7e, 0x00, 
0x01, 0x11, 0x11, 0xfe, 0x01, 0xfe, 0x11, 0x01, 
0xf5, 0x0a, 0x0a, 0x0a, 0x6e, 0x0a, 0x0a, 0x0a, 
0x7d, 0xf7, 0xde, 0xfb, 0xfe, 0xb7, 0xfd, 0xdf, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xf5, 0xf5, 0xf5, 0x81, 0x81, 0xf5, 0xf5, 0xf5, 
0xff, 0xff, 0xff, 0x00, 0xff, 0x00, 0xff, 0xff, 
0xff, 0xff, 0xff, 0x01, 0xfd, 0x05, 0xf5, 0xf5, 
0xf5, 0xf5, 0xf5, 0x05, 0xfd, 0x01, 0xff, 0xff, 
0xf5, 0xf5, 0xf5, 0x80, 0x83, 0xf0, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xf0, 0x83, 0x80, 0xf5, 0xf5, 
0xf5, 0xf5, 0xf5, 0x05, 0xfd, 0x05, 0xf5, 0xf5, 
0xf5, 0xf5, 0xf5, 0x04, 0xff, 0x00, 0xff, 0xff, 
0xf5, 0xf5, 0xf5, 0xf4, 0xf7, 0xf4, 0xf5, 0xf5, 
0xff, 0xff, 0xff, 0x00, 0xff, 0x04, 0xf5, 0xf5, 
0xf5, 0xf5, 0xf5, 0x04, 0xff, 0x04, 0xf5, 0xf5, 
0xff, 0x55, 0xff, 0xfd, 0xff, 0xfd, 0xff, 0xfd, 
0xff, 0xfd, 0xff, 0xfd, 0xff, 0xfd, 0xff, 0xfd, 
0xff, 0xfd, 0xff, 0xfd, 0xff, 0xfd, 0xff, 0x55, 
0xff, 0x55, 0xff, 0xfd, 0xff, 0xfd, 0xff, 0xfd, 
0xff, 0xfd, 0xff, 0xfd, 0xff, 0xfd, 0xff, 0xfd, 
0xff, 0xfd, 0xff, 0xfd, 0xff, 0xfd, 0xff, 0x55, 
0xff, 0x55, 0xff, 0xfd, 0xff, 0xfd, 0xff, 0xfd, 
0xff, 0xfd, 0xff, 0xfd, 0xff, 0xfd, 0xff, 0xfd, 
0xff, 0xfd, 0xff, 0xfd, 0xff, 0xfd, 0xff, 0x55, 
0xff, 0x01, 0xe9, 0xe5, 0x31, 0x5d, 0x9d, 0x31, 
0xe5, 0xa9, 0x01, 0xff, 0xff, 0x01, 0xbd, 0xe5, 
0xd1, 0x49, 0x65, 0xfd, 0x35, 0x9d, 0x59, 0x01, 
0xff, 0x0f, 0xf7, 0xfb, 0x01, 0xfd, 0xfd, 0xfd, 
0xfd, 0x11, 0xd7, 0xd7, 0x37, 0xf7, 0x17, 0xd7, 
0xd7, 0x37, 0xf1, 0xfd, 0xfd, 0xfd, 0xfd, 0x01, 
0x80, 0xe0, 0xf0, 0xf0, 0xf8, 0xfe, 0xee, 0xff, 
0xff, 0x55, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0x81, 0xed, 0xed, 0x93, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x55, 
0xff, 0x55, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xc3, 0xbd, 0xbd, 0xdb, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x55, 
0xff, 0x55, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xbd, 0x81, 0xbd, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x55, 
0xff, 0x18, 0xdb, 0xda, 0x1b, 0x9a, 0x5a, 0x1b, 
0xdb, 0xbd, 0x66, 0xc3, 0xcb, 0x66, 0xbd, 0x5b, 
0x98, 0x1a, 0x59, 0xd8, 0x1b, 0x9a, 0x5a, 0x18, 
0xff, 0x00, 0x3f, 0x5f, 0x60, 0x6f, 0x6f, 0x6f, 
0x6f, 0x68, 0x2e, 0xae, 0xaf, 0xaf, 0xa8, 0x2b, 
0x6b, 0x6c, 0x6f, 0x6f, 0x6f, 0xaf, 0xcf, 0xe0, 
0xff, 0xfe, 0xfc, 0xd8, 0xf8, 0xf0, 0xe0, 0x80, 
0xff, 0x55, 0xff, 0x7f, 0xff, 0x7f, 0xff, 0x7f, 
0xff, 0x7f, 0xff, 0x7f, 0xff, 0x7f, 0xff, 0x7f, 
0xff, 0x7f, 0xff, 0x7f, 0xff, 0x7f, 0xff, 0x55, 
0xff, 0x55, 0xff, 0x7f, 0xff, 0x7f, 0xff, 0x7f, 
0xff, 0x7f, 0xff, 0x7f, 0xff, 0x7f, 0xff, 0x7f, 
0xff, 0x7f, 0xff, 0x7f, 0xff, 0x7f, 0xff, 0x55, 
0xff, 0x55, 0xff, 0x7f, 0xff, 0x7f, 0xff, 0x7f, 
0xff, 0x7f, 0xff, 0x7f, 0xff, 0x7f, 0xff, 0x7f, 
0xff, 0x7f, 0xff, 0x7f, 0xff, 0x7f, 0xff, 0x55, 
0xff, 0x00, 0x27, 0x15, 0x4f, 0x7e, 0x66, 0x4b, 
0x52, 0x67, 0x00, 0xff, 0xff, 0x00, 0x77, 0x5e, 
0x7c, 0x4d, 0x26, 0x17, 0x4d, 0x7e, 0x76, 0x00, 
0xff, 0x81, 0xa5, 0x81, 0xa1, 0x85, 0x81, 0xff, 
0xc0, 0xcf, 0xd0, 0xd7, 0xd7, 0xd7, 0xe7, 0xf0, 
0xff, 0x81, 0x85, 0xa1, 0x85, 0xa1, 0x81, 0xff, 
0x01, 0x07, 0x0f, 0x1f, 0x1b, 0x3f, 0x7f, 0xff, 
0xff, 0xff, 0xc3, 0x3d, 0xa5, 0xc5, 0x6d, 0xf3, 
0x5b, 0xfd, 0x00, 0xfe, 0xfe, 0xfe, 0xfe, 0x0e, 
0x6e, 0x6e, 0x9e, 0xfe, 0xfe, 0xfe, 0xfe, 0x00, 
0xff, 0x1f, 0xef, 0x57, 0xfb, 0x01, 0xfd, 0x7d, 
0x71, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x3b, 
0x41, 0x5d, 0xdd, 0xdd, 0xdd, 0x5d, 0x9d, 0xc1, 
0xff, 0x01, 0x7d, 0x7d, 0x01, 0xed, 0xed, 0x6d, 
0xad, 0xa1, 0xbf, 0xbf, 0xa1, 0xad, 0xad, 0x61, 
0xff, 0xff, 0xff, 0x01, 0x55, 0xa9, 0x01, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0x07, 0xfb, 0x01, 0xfd, 0x7d, 0x7d, 0x7d, 
0x7d, 0x7d, 0x7d, 0x7d, 0x7d, 0x7d, 0x7d, 0x41, 
0x5f, 0x5f, 0x5f, 0x5f, 0x5f, 0x5f, 0xdf, 0x1f, 
0xff, 0x7f, 0x3d, 0x1f, 0x1f, 0x0f, 0x07, 0x01, 
0xff, 0x01, 0x56, 0xff, 0x55, 0xff, 0xd5, 0xff, 
0x75, 0xbf, 0xc0, 0x5f, 0xdf, 0x5f, 0xdf, 0x5c, 
0xdf, 0x5f, 0xdc, 0x5f, 0xdf, 0x5f, 0x9f, 0xc0, 
0xff, 0x00, 0xff, 0x95, 0xff, 0x24, 0xfe, 0x00, 
0xff, 0xff, 0xc3, 0xbd, 0xbd, 0xdb, 0xff, 0xff, 
0xff, 0x00, 0xfe, 0xfe, 0xfe, 0xe0, 0xef, 0x0f, 
0xff, 0xff, 0xff, 0x07, 0xfb, 0x01, 0xfe, 0xff, 
0xff, 0xff, 0xbd, 0x81, 0xbd, 0xff, 0xff, 0xff, 
0xfe, 0x01, 0xff, 0x26, 0xda, 0xda, 0x26, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0x00, 0xff, 0x54, 0xfe, 0x00, 0xff, 0xff, 
0xff, 0x03, 0xdb, 0xdb, 0xfb, 0xff, 0x03, 0x7b, 
0x7b, 0x87, 0xff, 0xff, 0xff, 0x00, 0xff, 0x00, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0x80, 0x9d, 0xaf, 0xb7, 0x9b, 0xbd, 0x96, 
0xbf, 0x95, 0xbf, 0x95, 0xbf, 0x95, 0xbf, 0xd5, 
0xef, 0x85, 0xb3, 0xb5, 0xb6, 0xb6, 0xb6, 0x80, 
0xff, 0x00, 0x3f, 0x5a, 0x6f, 0x55, 0x7b, 0x54, 
0x55, 0x7d, 0x55, 0x75, 0x5d, 0x75, 0x6d, 0x65, 
0x69, 0x6c, 0x6f, 0x6f, 0x6f, 0xaf, 0xcf, 0xe0, 
0xff, 0x9f, 0x6f, 0x6c, 0x9b, 0xf7, 0xee, 0xed, 
0xeb, 0xeb, 0xeb, 0xeb, 0xeb, 0xf3, 0xfb, 0x05, 
0x76, 0x47, 0x5f, 0x59, 0x56, 0x56, 0x19, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0x00, 0x3f, 0x55, 0x6f, 0x70, 0x37, 0x17, 
0x17, 0x17, 0x57, 0x77, 0x37, 0x17, 0x17, 0x17, 
0x57, 0x77, 0x77, 0x57, 0x47, 0x50, 0x9f, 0xc0, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0x01, 0xfd, 0xfd, 0x7d, 0x9d, 0xed, 0x05, 
0xf9, 0xad, 0x56, 0xaa, 0x56, 0xaa, 0x56, 0xaa, 
0x55, 0xf9, 0x05, 0xed, 0x05, 0xf9, 0xad, 0x56, 
0xaa, 0x56, 0xaa, 0x56, 0xaa, 0x55, 0xfb, 0x07, 
0xff, 0x01, 0x6d, 0x6d, 0x6d, 0x6d, 0x45, 0x45, 
0x6d, 0x01, 0xf7, 0x9b, 0xfd, 0x15, 0xd5, 0x55, 
0x5d, 0xd5, 0x55, 0x55, 0x5d, 0x55, 0x55, 0xd5, 
0x5d, 0x55, 0xd5, 0x15, 0xfd, 0x9b, 0xf7, 0x0f, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0x00, 0x7f, 0xc0, 0xbf, 0x7f, 0xff, 0xf8, 
0xfb, 0xf6, 0xed, 0xea, 0xed, 0x6a, 0xad, 0xca, 
0xc5, 0xbb, 0x7c, 0xff, 0xfc, 0xfb, 0xf6, 0xed, 
0xea, 0x6d, 0xaa, 0xcd, 0xea, 0x05, 0xfb, 0xfc, 
0xff, 0x01, 0x25, 0x01, 0x25, 0x01, 0x25, 0x01, 
0xff, 0x00, 0xff, 0x24, 0xff, 0x00, 0xff, 0x00, 
0x00, 0x03, 0x82, 0x42, 0x42, 0x42, 0x82, 0x03, 
0x00, 0x00, 0xff, 0x00, 0xff, 0x24, 0xff, 0x00, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0x00, 0xef, 0xf7, 0x9b, 0xfc, 0x00, 
0xfe, 0xfe, 0xfe, 0xce, 0x46, 0x12, 0x9e, 0xde, 
0xfe, 0xfe, 0xfe, 0x00, 0x76, 0x56, 0x76, 0x8e, 
0xfe, 0x8f, 0x77, 0x57, 0x77, 0x8e, 0xfe, 0x00, 
0xe3, 0x80, 0xa2, 0x80, 0xa2, 0x00, 0x22, 0x80, 
0xff, 0x00, 0xff, 0x49, 0xff, 0x00, 0xff, 0x01, 
0x01, 0x81, 0x83, 0x85, 0x85, 0x85, 0x83, 0x81, 
0x01, 0x01, 0xff, 0x00, 0xff, 0x49, 0xff, 0x00, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0x00, 0x5f, 0x4f, 0x56, 0x5b, 0x5c, 
0x55, 0x5d, 0x55, 0x5d, 0x55, 0x55, 0x5d, 0x55, 
0x6d, 0x75, 0x79, 0x60, 0x5d, 0x55, 0x5d, 0x63, 
0x7f, 0x63, 0x5d, 0x55, 0x5d, 0x63, 0x7f, 0x00, 
0xff, 0x00, 0x7e, 0x70, 0x77, 0x74, 0x74, 0x04, 
0xfc, 0xe0, 0xdf, 0xb2, 0x7f, 0x50, 0x57, 0x54, 
0x74, 0x57, 0x54, 0x54, 0x74, 0x54, 0x54, 0x57, 
0x74, 0x54, 0x57, 0x50, 0x7f, 0xb2, 0xdf, 0xe0, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0x01, 0x6d, 0x68, 0x6a, 0x0a, 0x78, 0x01, 
0xff, 0xc1, 0xd5, 0xd4, 0x14, 0x55, 0x41, 0x1f, 
0x21, 0x2d, 0xed, 0xed, 0x0d, 0x7d, 0x7d, 0x01, 
0xff, 0x80, 0xb6, 0xb6, 0x80, 0xb6, 0xb6, 0x80, 
0x00, 0x7e, 0x7e, 0x00, 0x7e, 0x66, 0x66, 0x00, 
0xff, 0xc1, 0x1d, 0x5d, 0x5d, 0x40, 0x7e, 0x00, 
0x07, 0x57, 0x57, 0x57, 0x50, 0x02, 0xfa, 0xf8, 
0xff, 0xc0, 0x1e, 0x5e, 0x40, 0x1e, 0xde, 0xc0, 
0xff, 0x8f, 0x77, 0x3b, 0x1d, 0x7e, 0x81, 0xff, 
0xff, 0x9f, 0x63, 0x3d, 0x1e, 0x79, 0x87, 0xff, 
0xff, 0x83, 0x7d, 0x1b, 0x3b, 0x77, 0x8f, 0xff, 
0xff, 0x9f, 0x67, 0x3b, 0x37, 0x7b, 0xa3, 0x9f, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xdf, 0xa3, 0xab, 0xa3, 0xaf, 0xcf, 0xb7, 
0xff, 0x1f, 0x07, 0x01, 0x6a, 0x01, 0x07, 0x1f, 
0xff, 0xff, 0xf5, 0xf5, 0x00, 0xf5, 0xf5, 0xff, 
0xff, 0xef, 0x07, 0xc3, 0x01, 0x23, 0x07, 0xef, 
0xff, 0xff, 0x00, 0x2a, 0x80, 0x2a, 0x00, 0xff, 
0xff, 0x03, 0x1d, 0x02, 0x1d, 0x1e, 0x1f, 0x1f, 
0xff, 0xff, 0xe7, 0xa3, 0x89, 0xcf, 0xef, 0xff, 
0xff, 0xf3, 0xe9, 0x15, 0xe9, 0xf3, 0xff, 0xff, 
0xff, 0xc0, 0xa1, 0x13, 0x0b, 0x85, 0xc0, 0xff, 
0xff, 0xff, 0x05, 0x01, 0x05, 0xdb, 0xe7, 0xff, 
0xff, 0xcf, 0x97, 0x1b, 0x63, 0xa7, 0xcf, 0xff, 
0x00, 0x70, 0x77, 0x77, 0x74, 0x77, 0x70, 0x01, 
0xff, 0xff, 0xb7, 0xab, 0x01, 0xab, 0xdb, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 
0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 

};
#endif


// Currently visible tiles are cached so they don't need to be recalculated between frames
uint8_t VisibleTileCache[VISIBLE_TILES_X * VISIBLE_TILES_Y];
int8_t CachedScrollX, CachedScrollY;
uint8_t AnimationFrame = 0;

// A map of which tiles should be on fire when a building is on fire
#define FIREMAP_SIZE 16
const uint8_t FireMap[FIREMAP_SIZE] PROGMEM =
{ 1,2,3,1,2,3,1,3,1,2,3,2,2,1,3,1 };

const uint8_t BuildingPopulaceMap[] PROGMEM =
{ 1,0xd,5,0xb,7,0xe,3,4,1,6,0xc,2,0xa,9,0xb,8 };

static const uint8_t* GetTileData(uint8_t tile)
{
	#ifdef MICROCITY_COLOR
    return TileImageData + (tile * 32);
#else
    return TileImageData + (tile * 8);
#endif
}

static inline uint8_t GetProcAtTile(uint8_t x, uint8_t y)
{
	return (uint8_t)((((y * 359)) ^ ((x * 431))));
}

static bool HasHighTraffic(int x, int y)
{
	// First check for buildings
	for (int n = 0; n < MAX_BUILDINGS; n++)
	{
		Building* building = &State.buildings[n];

		if (building->type && building->heavyTraffic)
		{
			if (x < building->x - 1 || y < building->y - 1)
				continue;
			const BuildingInfo* info = GetBuildingInfo(building->type);
			uint8_t width = pgm_read_byte(&info->width);
			uint8_t height = pgm_read_byte(&info->height);
			if (x > building->x + width || y > building->y + height)
				continue;

			return true;
		}
	}

	return false;
}

static uint8_t CalculateBuildingTile(Building* building, uint8_t x, uint8_t y)
{
	const BuildingInfo* info = GetBuildingInfo(building->type);
	uint8_t height = pgm_read_byte(&info->height);
	uint8_t tile = pgm_read_byte(&info->drawTile);

	if (building->onFire)
	{
		if (!((building->type == Industrial || building->type == Commercial || building->type == Residential)
			&& x == 1 && y == 1))
		{
			int index = y * height + x + GetProcAtTile(building->x, building->y);
			bool onFire = building->onFire >= pgm_read_byte(&FireMap[index & (FIREMAP_SIZE - 1)]);

			if (onFire)
			{
				uint8_t procVal = GetProcAtTile(building->x + x, building->y + y);
				return FIRST_FIRE_TILE + (procVal & 3);
			}
		}
	}

	if (IsRubble(building->type))
		return RUBBLE_TILE;

	// Industrial, commercial and residential buildings have different tiles based on the population density
	if (building->type == Industrial || building->type == Commercial || building->type == Residential)
	{
		if (building->populationDensity >= MAX_POPULATION_DENSITY - 1)
		{
			tile += 48;
		}
		else if (x != 1 || y != 1)
		{
			int index = y * height + x + GetProcAtTile(building->x, building->y);
			bool hasBuilding = building->populationDensity >= pgm_read_byte(&BuildingPopulaceMap[index & 0xf]);

			if (hasBuilding)
			{
				uint8_t procVal = GetProcAtTile(x, y);
				return FIRST_BUILDING_TILE + (procVal & 7);
			}
		}
	}

	tile += y * 16;
	tile += x;
	return tile;
}

// Calculate which visible tile to use
static uint8_t CalculateTile(int x, int y)
{
	// Check out of range
	if (x < 0 || y < 0 || x >= MAP_WIDTH || y >= MAP_HEIGHT)
		return 0;

	// First check for buildings
	for (int n = 0; n < MAX_BUILDINGS; n++)
	{
		Building* building = &State.buildings[n];

		if (building->type)
		{
			if (x < building->x || y < building->y)
				continue;
			const BuildingInfo* info = GetBuildingInfo(building->type);
			uint8_t width = pgm_read_byte(&info->width);
			uint8_t height = pgm_read_byte(&info->height);
			if (x < building->x + width && y < building->y + height)
			{
				return CalculateBuildingTile(building, x - building->x, y - building->y);
			}
		}
	}

	// Next check for roads / powerlines
	uint8_t connections = GetConnections(x, y);

	if (connections == RoadMask)
	{
		int variant = GetConnectivityTileVariant(x, y, connections);

		if(!IsTerrainClear(x, y))
			return FIRST_ROAD_BRIDGE_TILE + (variant & 1);
    
		if (HasHighTraffic(x, y))
			return FIRST_ROAD_TRAFFIC_TILE + variant;
		return FIRST_ROAD_TILE + variant;
	}
	else if (connections == PowerlineMask)
	{
		int variant = GetConnectivityTileVariant(x, y, connections);

		 if(!IsTerrainClear(x, y))
			return FIRST_POWERLINE_BRIDGE_TILE + (variant & 1);
		
		return FIRST_POWERLINE_TILE + variant;
	}
	else if (connections == (PowerlineMask | RoadMask))
	{
		int variant = GetConnectivityTileVariant(x, y, RoadMask) & 1;
		return FIRST_POWERLINE_ROAD_TILE + variant;
	}

	return GetTerrainTile(x, y);
}

static inline uint8_t GetCachedTile(int x, int y)
{
	//// Uncomment to visualise power connectivity
	/*
	if (AnimationFrame & 4)
	{
		x += CachedScrollX;
		y += CachedScrollY;
		int index = y * MAP_WIDTH + x;
		int mask = 1 << (index & 7);
		uint8_t val = GetPowerGrid()[index >> 3];

		return (val & mask) != 0 ? 1 : 0;
	}
	*/
	////


	uint8_t tile = VisibleTileCache[y * VISIBLE_TILES_X + x];

	// Animate water tiles
	if (tile >= FIRST_WATER_TILE && tile <= LAST_WATER_TILE)
	{
		tile = FIRST_WATER_TILE + ((tile - FIRST_WATER_TILE + (AnimationFrame >> 1)) & 3);
	}

	// Animate fire tiles
	if (tile >= FIRST_FIRE_TILE && tile <= LAST_FIRE_TILE)
	{
		tile = FIRST_FIRE_TILE + ((tile - FIRST_FIRE_TILE + (AnimationFrame >> 1)) & 3);
	}

	// Animate traffic tiles
	if ((AnimationFrame & 4) && tile >= FIRST_ROAD_TRAFFIC_TILE && tile <= LAST_ROAD_TRAFFIC_TILE)
	{
		tile += 16;
	}

	return tile;
}

static void ResetVisibleTileCache(void)
{
	CachedScrollX = UIState.scrollX >> TILE_SIZE_SHIFT;
	CachedScrollY = UIState.scrollY >> TILE_SIZE_SHIFT;

	for (int y = 0; y < VISIBLE_TILES_Y; y++)
	{
		for (int x = 0; x < VISIBLE_TILES_X; x++)
		{
			VisibleTileCache[y * VISIBLE_TILES_X + x] = CalculateTile(x + CachedScrollX, y + CachedScrollY);
		}
	}
}

#ifdef MICROCITY_COLOR
static inline uint8_t ColorTilePixel(uint8_t tile, unsigned x, unsigned y)
{
    uint8_t pair = GetTileData(tile)[y * 4 + (x >> 1)];
    return (x & 1) ? pair & 15 : pair >> 4;
}
#endif

static void DrawTiles(void)
{
#ifdef MICROCITY_COLOR
    /* Exactly DISPLAY_WIDTH pixels per row: never fetch an extra tile after the last
     * pixel. In particular, odd horizontal scroll offsets can cross tiles. */
    unsigned offset_x = UIState.scrollX & 7;
    unsigned offset_y = UIState.scrollY & 7;
    uint8_t *out = Framebuffer;
    for (unsigned y = 0; y < DISPLAY_HEIGHT; ++y) {
        unsigned sy = y + offset_y;
        for (unsigned x = 0; x < DISPLAY_WIDTH; x += 2) {
            unsigned sx = x + offset_x;
            uint8_t a = ColorTilePixel(GetCachedTile(sx >> 3, sy >> 3), sx & 7, sy & 7);
            ++sx;
            uint8_t b = ColorTilePixel(GetCachedTile(sx >> 3, sy >> 3), sx & 7, sy & 7);
            *out++ = (a << 4) | b;
        }
    }
#else
	int tileX = 0;
	int offsetX = UIState.scrollX & (TILE_SIZE - 1);

	for (int col = 0; col < DISPLAY_WIDTH; col++)
	{
		int tileY = 0;
		int offsetY = UIState.scrollY & (TILE_SIZE - 1);
		uint8_t currentTile = GetCachedTile(tileX, tileY);
		uint8_t readBuf = pgm_read_byte(&GetTileData(currentTile)[offsetX]);
		readBuf >>= offsetY;

		for (int row = 0; row < DISPLAY_HEIGHT; row++)
		{
			PutPixel(col, row, readBuf & 1);

			offsetY = (offsetY + 1) & 7;
			readBuf >>= 1;

			if (!offsetY)
			{
				tileY++;
				currentTile = GetCachedTile(tileX, tileY);
				readBuf = pgm_read_byte(&GetTileData(currentTile)[offsetX]);
			}
		}

		offsetX = (offsetX + 1) & 7;
		if (!offsetX)
		{
			tileX++;
		}
	}
#endif
}

static void ScrollUp(int amount)
{
	CachedScrollY -= amount;
	int y = VISIBLE_TILES_Y - 1;

	for (int n = 0; n < VISIBLE_TILES_Y - amount; n++)
	{
		for (int x = 0; x < VISIBLE_TILES_X; x++)
		{
			VisibleTileCache[y * VISIBLE_TILES_X + x] = VisibleTileCache[(y - amount) * VISIBLE_TILES_X + x];
		}
		y--;
	}

	for (y = 0; y < amount; y++)
	{
		for (int x = 0; x < VISIBLE_TILES_X; x++)
		{
			VisibleTileCache[y * VISIBLE_TILES_X + x] = CalculateTile(x + CachedScrollX, y + CachedScrollY);
		}
	}
}

static void ScrollDown(int amount)
{
	CachedScrollY += amount;
	int y = 0;

	for (int n = 0; n < VISIBLE_TILES_Y - amount; n++)
	{
		for (int x = 0; x < VISIBLE_TILES_X; x++)
		{
			VisibleTileCache[y * VISIBLE_TILES_X + x] = VisibleTileCache[(y + amount) * VISIBLE_TILES_X + x];
		}
		y++;
	}

	y = VISIBLE_TILES_Y - 1;
	for (int n = 0; n < amount; n++)
	{
		for (int x = 0; x < VISIBLE_TILES_X; x++)
		{
			VisibleTileCache[y * VISIBLE_TILES_X + x] = CalculateTile(x + CachedScrollX, y + CachedScrollY);
		}
		y--;
	}
}

static void ScrollLeft(int amount)
{
	CachedScrollX -= amount;
	int x = VISIBLE_TILES_X - 1;

	for (int n = 0; n < VISIBLE_TILES_X - amount; n++)
	{
		for (int y = 0; y < VISIBLE_TILES_Y; y++)
		{
			VisibleTileCache[y * VISIBLE_TILES_X + x] = VisibleTileCache[y * VISIBLE_TILES_X + x - amount];
		}
		x--;
	}

	for (x = 0; x < amount; x++)
	{
		for (int y = 0; y < VISIBLE_TILES_Y; y++)
		{
			VisibleTileCache[y * VISIBLE_TILES_X + x] = CalculateTile(x + CachedScrollX, y + CachedScrollY);
		}
	}
}

static void ScrollRight(int amount)
{
	CachedScrollX += amount;
	int x = 0;

	for (int n = 0; n < VISIBLE_TILES_X - amount; n++)
	{
		for (int y = 0; y < VISIBLE_TILES_Y; y++)
		{
			VisibleTileCache[y * VISIBLE_TILES_X + x] = VisibleTileCache[y * VISIBLE_TILES_X + x + amount];
		}
		x++;
	}

	x = VISIBLE_TILES_X - 1;
	for (int n = 0; n < amount; n++)
	{
		for (int y = 0; y < VISIBLE_TILES_Y; y++)
		{
			VisibleTileCache[y * VISIBLE_TILES_X + x] = CalculateTile(x + CachedScrollX, y + CachedScrollY);
		}
		x--;
	}
}

static void DrawCursorRect(uint8_t cursorDrawX, uint8_t cursorDrawY, uint8_t cursorWidth, uint8_t cursorHeight)
{
	for (int n = 0; n < cursorWidth; n++)
	{
		uint8_t colour = ((n + AnimationFrame) & 4) != 0 ? 1 : 0;
		PutPixel(cursorDrawX + n, cursorDrawY + cursorHeight - 1, colour);
		PutPixel(cursorDrawX + cursorWidth - n - 1, cursorDrawY, colour);
	}

	for (int n = 0; n < cursorHeight; n++)
	{
		uint8_t colour = ((n + AnimationFrame) & 4) != 0 ? 1 : 0;
		PutPixel(cursorDrawX, cursorDrawY + n, colour);
		PutPixel(cursorDrawX + cursorWidth - 1, cursorDrawY + cursorHeight - n - 1, colour);
	}
}

static void DrawCursor(void)
{
	uint8_t cursorX, cursorY;
	int cursorWidth = TILE_SIZE, cursorHeight = TILE_SIZE;

	if (UIState.brush >= FirstBuildingBrush)
	{
		BuildingType buildingType = (BuildingType)(UIState.brush - FirstBuildingBrush + 1);
		GetBuildingBrushLocation(buildingType, &cursorX, &cursorY);
		const BuildingInfo* buildingInfo = GetBuildingInfo(buildingType);
		cursorWidth *= pgm_read_byte(&buildingInfo->width);
		cursorHeight *= pgm_read_byte(&buildingInfo->height);
	}
	else
	{
		cursorX = UIState.selectX;
		cursorY = UIState.selectY;
	}

	int cursorDrawX, cursorDrawY;
	cursorDrawX = (cursorX * 8) - UIState.scrollX;
	cursorDrawY = (cursorY * 8) - UIState.scrollY;

	if (cursorDrawX >= 0 && cursorDrawY >= 0 && cursorDrawX + cursorWidth < DISPLAY_WIDTH && cursorDrawY + cursorHeight < DISPLAY_HEIGHT)
	{
		DrawCursorRect(cursorDrawX, cursorDrawY, cursorWidth, cursorHeight);
	}
}

static void AnimatePowercuts(void)
{
	bool showPowercut = (AnimationFrame & 8) != 0;

	for (int n = 0; n < MAX_BUILDINGS; n++)
	{
		Building* building = &State.buildings[n];

		if (building->type && building->type != Park && !IsRubble(building->type))
		{
			int screenX = building->x + 1 - CachedScrollX;
			int screenY = building->y + 1 - CachedScrollY;

			if (screenX >= 0 && screenY >= 0 && screenX < VISIBLE_TILES_X && screenY < VISIBLE_TILES_Y)
			{
				if (showPowercut && !building->hasPower)
				{
					VisibleTileCache[screenY * VISIBLE_TILES_X + screenX] = POWERCUT_TILE;
				}
				else
				{
					VisibleTileCache[screenY * VISIBLE_TILES_X + screenX] = CalculateBuildingTile(building, 1, 1);
				}
			}
		}

	}
}

static void RefreshTile(uint8_t x, uint8_t y)
{
	int screenX = x - CachedScrollX;
	int screenY = y - CachedScrollY;

	if (screenX >= 0 && screenY >= 0 && screenX < VISIBLE_TILES_X && screenY < VISIBLE_TILES_Y)
	{
		VisibleTileCache[screenY * VISIBLE_TILES_X + screenX] = CalculateTile(x, y);
	}
}

static void SetTile(uint8_t x, uint8_t y, uint8_t tile)
{
	int screenX = x - CachedScrollX;
	int screenY = y - CachedScrollY;

	if (screenX >= 0 && screenY >= 0 && screenX < VISIBLE_TILES_X && screenY < VISIBLE_TILES_Y)
	{
		VisibleTileCache[screenY * VISIBLE_TILES_X + screenX] = tile;
	}
}

static void RefreshTileAndConnectedNeighbours(uint8_t x, uint8_t y)
{
	RefreshTile(x, y);

	if (x > 0 && GetConnections(x - 1, y))
		RefreshTile(x - 1, y);
	if (x < MAP_WIDTH - 1 && GetConnections(x + 1, y))
		RefreshTile(x + 1, y);
	if (y > 0 && GetConnections(x, y - 1))
		RefreshTile(x, y - 1);
	if (y < MAP_HEIGHT - 1 && GetConnections(x, y + 1))
		RefreshTile(x, y + 1);

}

static void RefreshBuildingTiles(Building* building)
{
	const BuildingInfo* info = GetBuildingInfo(building->type);
	uint8_t width = pgm_read_byte(&info->width);
	uint8_t height = pgm_read_byte(&info->height);

	for (int j = 0; j < height; j++)
	{
		uint8_t y = building->y + j;
		for (int i = 0; i < width; i++)
		{
			uint8_t x = building->x + i;
			int screenX = x - CachedScrollX;
			int screenY = y - CachedScrollY;

			if (screenX >= 0 && screenY >= 0 && screenX < VISIBLE_TILES_X && screenY < VISIBLE_TILES_Y)
			{
				VisibleTileCache[screenY * VISIBLE_TILES_X + screenX] = CalculateBuildingTile(building, i, j);
			}
		}
	}

	// Refresh traffic
	uint8_t x1 = building->x > 0 ? building->x - 1 : 0;
	uint8_t x2 = building->x + width < MAP_WIDTH ? building->x + width : MAP_WIDTH - 1;
	uint8_t y1 = building->y > 0 ? building->y - 1 : 0;
	uint8_t y2 = building->y + height < MAP_HEIGHT ? building->y + height : MAP_HEIGHT - 1;

	for (int i = x1; i <= x2; i++)
	{
		if (GetConnections(i, y1) & RoadMask)
			RefreshTile(i, y1);
		if (GetConnections(i, y2) & RoadMask)
			RefreshTile(i, y2);
	}
	for (int i = y1; i <= y2; i++)
	{
		if (GetConnections(x1, i) & RoadMask)
			RefreshTile(x1, i);
		if (GetConnections(x2, i) & RoadMask)
			RefreshTile(x2, i);
	}

}

static void DrawTileAt(uint8_t tile, int x, int y)
{
#ifdef MICROCITY_COLOR
    DrawColorBitmap(GetTileData(tile), x, y, TILE_SIZE, TILE_SIZE);
#else
	for (int col = 0; col < TILE_SIZE; col++)
	{
		uint8_t readBuf = pgm_read_byte(&GetTileData(tile)[col]);

		for (int row = 0; row < TILE_SIZE; row++)
		{
			uint8_t colour = readBuf & 1;
			readBuf >>= 1;
			PutPixel(x + col, y + row, colour);
		}
	}
#endif
}

static void DrawFilledRect(uint8_t x, uint8_t y, uint8_t w, uint8_t h, uint8_t colour)
{
	for (int j = 0; j < h; j++)
	{
		for (int i = 0; i < w; i++)
		{
			PutPixel(x + i, y + j, colour);
		}
	}
}

static void DrawRect(uint8_t x, uint8_t y, uint8_t w, uint8_t h, uint8_t colour)
{
	for (int j = 0; j < w; j++)
	{
		PutPixel(x + j, y, colour);
		PutPixel(x + j, y + h - 1, colour);
	}

	for (int j = 1; j < h - 1; j++)
	{
		PutPixel(x, y + j, colour);
		PutPixel(x + w - 1, y + j, colour);
	}
}

const char FireReportedStr[] PROGMEM = "Fire reported!";

static void DrawUI(void)
{
	if (UIState.state == ShowingToolbar)
	{
		uint8_t buttonX = 1;
        int slots=(DISPLAY_WIDTH-2)/(TILE_SIZE+1);
        int first=UIState.selection>=slots ? UIState.selection-slots+1 : 0;

		DrawFilledRect(0, DISPLAY_HEIGHT - TILE_SIZE - 2, DISPLAY_WIDTH, TILE_SIZE + 2, 1);
		DrawFilledRect(0, DISPLAY_HEIGHT - TILE_SIZE - 2 - FONT_HEIGHT - 1, DISPLAY_WIDTH, FONT_HEIGHT + 2, 1);

		for (int n = first; n < NUM_TOOLBAR_BUTTONS && n < first+slots; n++)
		{
			DrawTileAt(FIRST_BRUSH_TILE + n, buttonX, DISPLAY_HEIGHT - TILE_SIZE - 1);
			buttonX += TILE_SIZE + 1;
		}

		DrawCursorRect((UIState.selection-first) * (TILE_SIZE + 1), DISPLAY_HEIGHT - TILE_SIZE - 2, TILE_SIZE + 2, TILE_SIZE + 2);
		const char* currentSelection = GetToolbarString(UIState.selection);
		DrawString(currentSelection, 1, DISPLAY_HEIGHT - FONT_HEIGHT - TILE_SIZE - 2);

		uint16_t cost = 0;

		switch (UIState.selection)
		{
		case 0: cost = BULLDOZER_COST; break;
		case 1: cost = ROAD_COST; break;
		case 2: cost = POWERLINE_COST; break;
		default:
		{
			int buildingIndex = 1 + UIState.selection - FirstBuildingBrush;
			if (buildingIndex < Num_BuildingTypes)
			{
				const BuildingInfo* buildingInfo = GetBuildingInfo(buildingIndex);
				cost = pgm_read_word(&buildingInfo->cost);
			}
		}
		break;
		}
		if (cost > 0)
		{
			DrawCurrency(cost, DISPLAY_WIDTH-FONT_WIDTH-1, DISPLAY_HEIGHT - FONT_HEIGHT - TILE_SIZE - 2);
		}
	}
	else if (UIState.state == InGameDisaster)
	{
		int strLen = strlen_P(FireReportedStr);
		int x = DISPLAY_WIDTH / 2 - strLen * (FONT_WIDTH / 2);
		DrawFilledRect(x - 1, DISPLAY_HEIGHT - TILE_SIZE - 2, 2 + strlen_P(FireReportedStr) * FONT_WIDTH + 2, TILE_SIZE + 2, 1);

		if (UIState.selection & 4)
		{
			DrawString(FireReportedStr, x, DISPLAY_HEIGHT - FONT_HEIGHT - 1);
		}
	}
	else
	{
		// Current brush at bottom left
		const char* currentSelection = GetToolbarString(UIState.brush);
		DrawFilledRect(0, DISPLAY_HEIGHT - TILE_SIZE - 2, TILE_SIZE + 2 + strlen_P(currentSelection) * FONT_WIDTH + 2, TILE_SIZE + 2, 1);
		DrawTileAt(FIRST_BRUSH_TILE + UIState.brush, 1, DISPLAY_HEIGHT - TILE_SIZE - 1);
		DrawString(currentSelection, TILE_SIZE + 2, DISPLAY_HEIGHT - FONT_HEIGHT - 1);
	}

	// Date at top left
	DrawFilledRect(0, 0, FONT_WIDTH * 8 + 2, FONT_HEIGHT + 2, 1);
	DrawString(GetMonthString(State.month), 1, 1);
	DrawInt(State.year + 1900, FONT_WIDTH * 4 + 1, 1);

	// Funds at top right
	uint8_t currencyStrLen = DrawCurrency(State.money, DISPLAY_WIDTH - FONT_WIDTH - 1, 1);
	DrawRect(DISPLAY_WIDTH - 2 - currencyStrLen * FONT_WIDTH, 0, currencyStrLen * FONT_WIDTH + 2, FONT_HEIGHT + 2, 1);
}

static void DrawInGame(void)
{
	// Check to see if scrolled to a new location and need to update the visible tile cache
	int tileScrollX = UIState.scrollX >> TILE_SIZE_SHIFT;
	int tileScrollY = UIState.scrollY >> TILE_SIZE_SHIFT;
	int scrollDiffX = tileScrollX - CachedScrollX;
	int scrollDiffY = tileScrollY - CachedScrollY;

    /* A full reset updates both axes. Do it once, before applying either
     * cached delta, or a large diagonal jump shifts the second axis twice. */
    if (scrollDiffX <= -VISIBLE_TILES_X || scrollDiffX >= VISIBLE_TILES_X ||
        scrollDiffY <= -VISIBLE_TILES_Y || scrollDiffY >= VISIBLE_TILES_Y) {
        ResetVisibleTileCache();
        scrollDiffX = scrollDiffY = 0;
    }

	if (scrollDiffX < 0)
	{
		if (scrollDiffX > -VISIBLE_TILES_X)
		{
			ScrollLeft(-scrollDiffX);
		}
		else
		{
			ResetVisibleTileCache();
		}
	}
	else if (scrollDiffX > 0)
	{
		if (scrollDiffX < VISIBLE_TILES_X)
		{
			ScrollRight(scrollDiffX);
		}
		else
		{
			ResetVisibleTileCache();
		}
	}

	if (scrollDiffY < 0)
	{
		if (scrollDiffY > -VISIBLE_TILES_Y)
		{
			ScrollUp(-scrollDiffY);
		}
		else
		{
			ResetVisibleTileCache();
		}
	}
	else if (scrollDiffY > 0)
	{
		if (scrollDiffY < VISIBLE_TILES_Y)
		{
			ScrollDown(scrollDiffY);
		}
		else
		{
			ResetVisibleTileCache();
		}
	}

	AnimatePowercuts();

	DrawTiles();

	if (UIState.state == InGame || UIState.state == InGameDisaster)
	{
		DrawCursor();
	}

	DrawUI();
}

const char BudgetHeaderStr[] PROGMEM =		"Budget report for";
const char TaxRateStr[] PROGMEM =			"Tax rate         <   % >";
const char TaxesCollectedStr[] PROGMEM =	"Taxes collected";
const char PoliceBudgetStr[] PROGMEM =		"Police budget";
const char FireBudgetStr[] PROGMEM =		"Fire budget";
const char RoadBudgetStr[] PROGMEM =		"Road budget";
const char CashFlowStr[] PROGMEM =			"Cash flow";

static void DrawBudgetMenu(void)
{
    int w=MIN(DISPLAY_WIDTH-4,144), x=(DISPLAY_WIDTH-w)/2;
    int y=(DISPLAY_HEIGHT-60)/2, right=x+w-FONT_WIDTH-3;
    DrawFilledRect(x,y,w,60,1); DrawRect(x,y,w,60,0);
    DrawString("Budget",x+3,y+2);
    DrawInt(State.year ? State.year+1899 : 1900,right-16,y+2);
    DrawString("Tax < >",x+3,y+10); DrawInt(State.taxRate,right-8,y+10);
    DrawString("%",right,y+10);
    DrawString("Taxes",x+3,y+17); DrawCurrency(State.taxesCollected,right,y+17);
    DrawString("Fire",x+3,y+24); DrawCurrency(State.fireBudget*100,right,y+24);
    DrawString("Police",x+3,y+31); DrawCurrency(State.policeBudget*100,right,y+31);
    DrawString("Roads",x+3,y+38); DrawCurrency(State.roadBudget,right,y+38);
    DrawString("Net",x+3,y+45);
    DrawCurrency(State.taxesCollected-State.roadBudget-100*(State.policeBudget+State.fireBudget),right,y+45);
    DrawString("Select:close",x+3,y+53);
    if (UIState.selection<MIN_BUDGET_DISPLAY_TIME) ++UIState.selection;
}

static void Draw(void)
{
	switch (UIState.state)
	{
	case InGame:
	case InGameDisaster:
	case ShowingToolbar:
		DrawInGame();
		break;
	case BudgetMenu:
		DrawBudgetMenu();
		break;
	}

	AnimationFrame++;

}


/* ---- Rockbox platform, persistence, and entry point ---- */

#ifdef MICROCITY_COLOR
static void PutColorPixel(int x, int y, uint8_t index)
{
    if ((unsigned)x >= DISPLAY_WIDTH || (unsigned)y >= DISPLAY_HEIGHT) return;
    uint8_t *pixel = &Framebuffer[y * (DISPLAY_WIDTH / 2) + (x >> 1)];
    index &= 15;
    if (x & 1) *pixel = (*pixel & 0xf0) | index;
    else *pixel = (*pixel & 0x0f) | (index << 4);
}

static void DrawColorBitmap(const uint8_t *bmp, int x, int y, int w, int h)
{
    /* Packed row-major indices, high nibble first, including opaque zeroes. */
    for (int j = 0; j < h; ++j)
        for (int i = 0; i < w; ++i) {
            unsigned n = j * w + i;
            uint8_t pair = bmp[n >> 1];
            PutColorPixel(x + i, y + j, (n & 1) ? pair & 15 : pair >> 4);
        }
}
#endif

static void PutPixel(int x, int y, uint8_t colour)
{
#ifdef MICROCITY_COLOR
    /* Existing font/UI primitives continue to pass logical black and white. */
    PutColorPixel(x, y, colour ? 15 : 0);
#else
    if ((unsigned)x >= DISPLAY_WIDTH || (unsigned)y >= DISPLAY_HEIGHT) return;
    unsigned offset = (y >> 3) * DISPLAY_WIDTH + x;
    uint8_t mask = 1u << (y & 7);
    if (colour) Framebuffer[offset] |= mask;
    else Framebuffer[offset] &= ~mask;
#endif
}

static uint8_t *GetPowerGrid(void) { return PowerGrid; }

static void Present(void)
{
    rb->lcd_set_viewport(NULL);
#if LCD_DEPTH > 1
    rb->lcd_set_foreground(LCD_WHITE);
    rb->lcd_set_background(LCD_BLACK);
    rb->lcd_set_drawmode(DRMODE_SOLID);
#else
    /* Rockbox 1-bit LCDs use 1=ink; Arduboy artwork uses 1=white. */
    rb->lcd_set_drawmode(DRMODE_SOLID | DRMODE_INVERSEVID);
#endif
#ifdef MICROCITY_COLOR
    for (int y=0;y<DISPLAY_HEIGHT;++y) {
        const uint8_t *row=&Framebuffer[y*(DISPLAY_WIDTH/2)];
        for (int x=0;x<DISPLAY_WIDTH*DISPLAY_SCALE;++x) {
            int px=x/DISPLAY_SCALE; uint8_t pair=row[px>>1];
            ColorScanline[x]=ColorPalette[(px&1) ? pair&15 : pair>>4];
        }
        for (int j=0;j<DISPLAY_SCALE;++j)
            rb->lcd_bitmap(ColorScanline,(LCD_WIDTH-DISPLAY_WIDTH*DISPLAY_SCALE)/2,
                           (LCD_HEIGHT-DISPLAY_HEIGHT*DISPLAY_SCALE)/2+y*DISPLAY_SCALE+j,
                           DISPLAY_WIDTH*DISPLAY_SCALE,1);
    }
#else
#if DISPLAY_SCALE == 1
    rb->lcd_mono_bitmap(Framebuffer,(LCD_WIDTH-DISPLAY_WIDTH)/2,
                       (LCD_HEIGHT-DISPLAY_HEIGHT)/2,DISPLAY_WIDTH,DISPLAY_HEIGHT);
#else
    for (int y=0;y<DISPLAY_HEIGHT;++y) {
        for (int x=0;x<DISPLAY_WIDTH*DISPLAY_SCALE;++x)
            MonoScanline[x]=(Framebuffer[(y>>3)*DISPLAY_WIDTH+x/DISPLAY_SCALE]>>(y&7))&1;
        for (int j=0;j<DISPLAY_SCALE;++j)
            rb->lcd_mono_bitmap(MonoScanline,(LCD_WIDTH-DISPLAY_WIDTH*DISPLAY_SCALE)/2,
                (LCD_HEIGHT-DISPLAY_HEIGHT*DISPLAY_SCALE)/2+y*DISPLAY_SCALE+j,
                DISPLAY_WIDTH*DISPLAY_SCALE,1);
    }
#endif
#endif
    rb->lcd_update();
}

#define CITY_SAVE_PATH PLUGIN_GAMES_DATA_DIR "/microcity.sav"
#define CITY_TEMP_PATH PLUGIN_GAMES_DATA_DIR "/microcity.tmp"
#define SAVE_CAPACITY 1280
static uint8_t SaveBuffer[SAVE_CAPACITY];
static GameState LoadedCity;

static uint32_t SaveChecksum(const uint8_t *data, size_t size)
{
    uint32_t crc = 0xffffffffu;
    while (size--) {
        crc ^= *data++;
        for (int bit = 0; bit < 8; ++bit)
            crc = (crc >> 1) ^ (0xedb88320u & (0u - (crc & 1)));
    }
    return ~crc;
}

static void StoreNumber(size_t *pos, uint32_t value, unsigned bytes)
{
    while (bytes--) { SaveBuffer[(*pos)++] = value & 255; value >>= 8; }
}

static uint32_t ReadNumber(size_t *pos, unsigned bytes)
{
    uint32_t value = 0;
    for (unsigned i = 0; i < bytes; ++i)
        value |= (uint32_t)SaveBuffer[(*pos)++] << (i * 8);
    return value;
}

/* Fixed wire layout, independent of CPU ABI, padding, and bitfield layout. */
static size_t EncodeCity(void)
{
    size_t p = 0;
    StoreNumber(&p, 0x4252434du, 4); /* "MCRB" */
    StoreNumber(&p, 1, 1);          /* format version */
    StoreNumber(&p, State.year, 2);
    StoreNumber(&p, State.month, 1);
    StoreNumber(&p, State.simulationStep, 1);
    StoreNumber(&p, (uint32_t)State.money, 4);
    for (unsigned i = 0; i < sizeof(State.connectionMap); ++i)
        StoreNumber(&p, State.connectionMap[i], 1);
    StoreNumber(&p, State.terrainType, 1);
    StoreNumber(&p, State.taxRate, 1);
    StoreNumber(&p, State.residentialPopulation, 2);
    StoreNumber(&p, State.industrialPopulation, 2);
    StoreNumber(&p, State.commercialPopulation, 2);
    StoreNumber(&p, (uint32_t)State.taxesCollected, 4);
    StoreNumber(&p, State.policeBudget, 1);
    StoreNumber(&p, State.fireBudget, 1);
    StoreNumber(&p, State.roadBudget, 2);
    StoreNumber(&p, State.timeToNextDisaster, 2);
    for (int i = 0; i < MAX_BUILDINGS; ++i) {
        const Building *b = &State.buildings[i];
        StoreNumber(&p, b->x, 1);
        StoreNumber(&p, b->y, 1);
        StoreNumber(&p, b->type, 1);
        StoreNumber(&p, b->populationDensity | (b->onFire << 4) |
                    (b->heavyTraffic << 6) | (b->hasPower << 7), 1);
    }
    StoreNumber(&p, UIState.selectX, 1);
    StoreNumber(&p, UIState.selectY, 1);
    StoreNumber(&p, UIState.brush, 1);
    StoreNumber(&p, UIState.autoBudget, 1);
    StoreNumber(&p, RandomState, 2);
    uint32_t crc = SaveChecksum(SaveBuffer, p);
    StoreNumber(&p, crc, 4);
    return p;
}

/* Version 1 is exactly 1137 bytes, including CRC. Do not derive this from
 * sizeof(GameState): saves must be portable between native and simulator. */
#define CITY_SAVE_SIZE (4+1+2+1+1+4+576+1+1+6+4+1+1+2+2+130*4+4+2+4)
typedef char save_capacity_check[(CITY_SAVE_SIZE <= SAVE_CAPACITY) ? 1 : -1];

static bool DecodeCity(size_t length)
{
    if (length != CITY_SAVE_SIZE) return false;
    size_t p = length - 4;
    if (ReadNumber(&p, 4) != SaveChecksum(SaveBuffer, length - 4)) return false;
    p = 0;
    if (ReadNumber(&p, 4) != 0x4252434du || ReadNumber(&p, 1) != 1) return false;
    GameState *s = &LoadedCity;
    rb->memset(s, 0, sizeof(*s));
    s->year = ReadNumber(&p, 2);
    s->month = ReadNumber(&p, 1);
    s->simulationStep = ReadNumber(&p, 1);
    s->money = (int32_t)ReadNumber(&p, 4);
    for (unsigned i = 0; i < sizeof(s->connectionMap); ++i)
        s->connectionMap[i] = ReadNumber(&p, 1);
    s->terrainType = ReadNumber(&p, 1);
    s->taxRate = ReadNumber(&p, 1);
    s->residentialPopulation = ReadNumber(&p, 2);
    s->industrialPopulation = ReadNumber(&p, 2);
    s->commercialPopulation = ReadNumber(&p, 2);
    s->taxesCollected = (int32_t)ReadNumber(&p, 4);
    s->policeBudget = ReadNumber(&p, 1);
    s->fireBudget = ReadNumber(&p, 1);
    s->roadBudget = ReadNumber(&p, 2);
    s->timeToNextDisaster = ReadNumber(&p, 2);
    if (s->month > 11 || s->simulationStep > SimulateNextMonth ||
        s->terrainType >= NUM_TERRAIN_TYPES || s->taxRate > 99 ||
        !s->timeToNextDisaster || s->timeToNextDisaster > MAX_TIME_BETWEEN_DISASTERS ||
        s->money < -100000000 || s->money > 100000000 ||
        s->taxesCollected < 0 || s->taxesCollected > 1000000 ||
        s->policeBudget > MAX_BUILDINGS || s->fireBudget > MAX_BUILDINGS ||
        s->roadBudget > MAP_WIDTH * MAP_HEIGHT ||
        s->residentialPopulation > MAX_BUILDINGS * MAX_POPULATION_DENSITY ||
        s->industrialPopulation > MAX_BUILDINGS * MAX_POPULATION_DENSITY ||
        s->commercialPopulation > MAX_BUILDINGS * MAX_POPULATION_DENSITY) return false;
    for (int i = 0; i < MAX_BUILDINGS; ++i) {
        unsigned x = ReadNumber(&p, 1), y = ReadNumber(&p, 1);
        unsigned type = ReadNumber(&p, 1), bits = ReadNumber(&p, 1);
        if (x >= MAP_WIDTH || y >= MAP_HEIGHT || type > Rubble4x4) return false;
        if (type) {
            const BuildingInfo *info = GetBuildingInfo(type);
            if (x + info->width > MAP_WIDTH || y + info->height > MAP_HEIGHT) return false;
        }
        Building *b = &s->buildings[i];
        b->x = x; b->y = y; b->type = type;
        b->populationDensity = bits & 15;
        b->onFire = (bits >> 4) & 3;
        b->heavyTraffic = (bits >> 6) & 1;
        b->hasPower = bits >> 7;
    }
    unsigned x = ReadNumber(&p, 1), y = ReadNumber(&p, 1);
    unsigned brush = ReadNumber(&p, 1), budget = ReadNumber(&p, 1);
    unsigned random = ReadNumber(&p, 2);
    if (x >= MAP_WIDTH || y >= MAP_HEIGHT || brush > LastBuildingBrush || budget > 1 || !random) return false;
    /* No live state changes until the complete file passes validation. */
    State = *s;
    RandomState = random;
    rb->memset(&UIState, 0, sizeof(UIState));
    UIState.brush = brush; UIState.autoBudget = budget; UIState.state = InGame;
    FocusTile(x, y);
    CountPopulation();
    CalculatePowerConnectivity();
    ResetVisibleTileCache();
    HasCity = true;
    return true;
}

static bool SaveToDisk(void)
{
    if (!HasCity) { rb->splash(HZ, "No city yet"); return false; }
    size_t size = EncodeCity();
    int fd = rb->open(CITY_TEMP_PATH, O_WRONLY | O_CREAT | O_TRUNC, 0666);
    if (fd < 0) { rb->splash(HZ, "Cannot open save"); return false; }
    size_t done = 0;
    while (done < size) {
        ssize_t n = rb->write(fd, SaveBuffer + done, size - done);
        if (n <= 0) break;
        done += n;
    }
    int closed = rb->close(fd);
    if (done != size || closed < 0 || rb->rename(CITY_TEMP_PATH, CITY_SAVE_PATH) < 0) {
        rb->remove(CITY_TEMP_PATH);
        rb->splash(HZ, "City save failed");
        return false;
    }
    rb->splash(HZ / 2, "City saved");
    return true;
}

void SaveCity(void) { (void)SaveToDisk(); }

static bool LoadCity(void)
{
    int fd = rb->open(CITY_SAVE_PATH, O_RDONLY);
    if (fd < 0) { rb->splash(HZ, "No saved city"); return false; }
    size_t done = 0;
    bool read_ok = true;
    while (done < sizeof(SaveBuffer)) {
        ssize_t n = rb->read(fd, SaveBuffer + done, sizeof(SaveBuffer) - done);
        if (n < 0) { read_ok = false; break; }
        if (n == 0) break;
        done += n;
    }
    rb->close(fd);
    if (!read_ok || !DecodeCity(done)) {
        rb->splash(HZ, "Invalid city save"); return false;
    }
    return true;
}

/* YP3: only four directions and center. Long-center is device-reserved.
 * Override PORT_CENTER_BUTTON if the board header uses a different name. */
#if defined(YP3_PAD) && CONFIG_KEYPAD == YP3_PAD
#ifndef PORT_CENTER_BUTTON
#if defined(BUTTON_SELECT)
#define PORT_CENTER_BUTTON BUTTON_SELECT
#elif defined(BUTTON_PLAY)
#define PORT_CENTER_BUTTON BUTTON_PLAY
#elif defined(BUTTON_CENTER)
#define PORT_CENTER_BUTTON BUTTON_CENTER
#elif defined(BUTTON_OK)
#define PORT_CENTER_BUTTON BUTTON_OK
#elif defined(BUTTON_PLAYPAUSE)
#define PORT_CENTER_BUTTON BUTTON_PLAYPAUSE
#else
#error "Define PORT_CENTER_BUTTON to the YP3 center button raw mask"
#endif
#endif
static const struct button_mapping yp3_context[]={
    {PLA_UP,BUTTON_UP,BUTTON_NONE}, {PLA_DOWN,BUTTON_DOWN,BUTTON_NONE},
    {PLA_LEFT,BUTTON_LEFT,BUTTON_NONE}, {PLA_RIGHT,BUTTON_RIGHT,BUTTON_NONE},
    {PLA_UP_REPEAT,BUTTON_UP|BUTTON_REPEAT,BUTTON_NONE},
    {PLA_DOWN_REPEAT,BUTTON_DOWN|BUTTON_REPEAT,BUTTON_NONE},
    {PLA_LEFT_REPEAT,BUTTON_LEFT|BUTTON_REPEAT,BUTTON_NONE},
    {PLA_RIGHT_REPEAT,BUTTON_RIGHT|BUTTON_REPEAT,BUTTON_NONE},
    {PLA_SELECT,PORT_CENTER_BUTTON,BUTTON_NONE},
    {PLA_SELECT_REL,PORT_CENTER_BUTTON|BUTTON_REL,BUTTON_NONE},
    {PLA_SELECT_REPEAT,PORT_CENTER_BUTTON|BUTTON_REPEAT,BUTTON_NONE},
    LAST_ITEM_IN_LIST
};
#define PORT_MAIN_CONTEXT yp3_context
#else
#define PORT_MAIN_CONTEXT pla_main_ctx
#endif

#ifdef HAVE_BLUETOOTH_HID
/* Game controller: A builds/confirms, B opens tools/back, Options or PS
 * pauses (PLA_EXIT opens the pause menu, which can quit) */
static const struct button_mapping pad_context[]={
    {PLA_SELECT,BUTTON_PAD_A,BUTTON_NONE},
    {PLA_SELECT_REL,BUTTON_PAD_A|BUTTON_REL,BUTTON_NONE},
    {PLA_SELECT_REPEAT,BUTTON_PAD_A|BUTTON_REPEAT,BUTTON_NONE},
    {PLA_CANCEL,BUTTON_PAD_B,BUTTON_NONE},
    {PLA_EXIT,BUTTON_PAD_MENU,BUTTON_NONE},
    {PLA_EXIT,BUTTON_PAD_HOME,BUTTON_NONE},
    LAST_ITEM_IN_LIST__NEXTLIST(CONTEXT_PLUGIN)
};
#endif

#ifdef HAVE_BLUETOOTH_HID
static const struct button_mapping *GameContexts[] = { pad_context, PORT_MAIN_CONTEXT,
#else
static const struct button_mapping *GameContexts[] = { PORT_MAIN_CONTEXT,
#endif
#ifdef HAVE_REMOTE_LCD
    pla_remote_ctx,
#endif
};
static bool SelectArmed, SelectHeld;
static long SelectSince;
static int SuppressRepeat;

static int ReadAction(int timeout)
{
#ifdef PORT_CENTER_BUTTON
    /* Common pause gesture: hold Select+Up for 0.5 s; the release is no click. */
    static unsigned long ChordSince; static bool ChordDone;
    if ((rb->button_status()&(PORT_CENTER_BUTTON|BUTTON_UP))==(PORT_CENTER_BUTTON|BUTTON_UP)) {
        if (!ChordSince) ChordSince=*rb->current_tick|1;
        else if (!ChordDone && *rb->current_tick-ChordSince>=(unsigned long)(HZ/2)) {
            ChordDone=true; SelectArmed=false; SelectHeld=true; SuppressRepeat=PLA_UP;
            return PLA_EXIT;
        }
    } else { ChordSince=0; ChordDone=false; }
#endif
    int a=pluginlib_getaction(timeout,GameContexts,ARRAYLEN(GameContexts));
    if ((a==PLA_LEFT_REPEAT && SuppressRepeat==PLA_LEFT) ||
        (a==PLA_RIGHT_REPEAT && SuppressRepeat==PLA_RIGHT) ||
        (a==PLA_UP_REPEAT && SuppressRepeat==PLA_UP)) return ACTION_NONE;
    if (a==PLA_LEFT || a==PLA_RIGHT || a==PLA_UP || a==PLA_SELECT) SuppressRepeat=0;
    if (a==PLA_SELECT) { SelectArmed=true; SelectHeld=false; SelectSince=*rb->current_tick; return ACTION_NONE; }
    if (a==PLA_SELECT_REPEAT) { SelectArmed=false; SelectHeld=true; return ACTION_NONE; }
    if (a==PLA_SELECT_REL) {
        bool click=SelectArmed && !SelectHeld &&
            (unsigned long)*rb->current_tick-(unsigned long)SelectSince<(unsigned)(HZ*3/5);
        SelectArmed=false; return click ? PLA_SELECT : ACTION_NONE;
    }
    if (a!=ACTION_NONE) SelectArmed=false;
    return a;
}

static uint8_t DirectionInput(int action)
{
    switch (action) {
    case PLA_LEFT: case PLA_LEFT_REPEAT: return INPUT_LEFT;
    case PLA_RIGHT: case PLA_RIGHT_REPEAT: return INPUT_RIGHT;
    case PLA_UP: case PLA_UP_REPEAT: return INPUT_UP;
    case PLA_DOWN: case PLA_DOWN_REPEAT: return INPUT_DOWN;
#ifdef HAVE_SCROLLWHEEL
    case PLA_SCROLL_BACK: case PLA_SCROLL_BACK_REPEAT: return INPUT_UP;
    case PLA_SCROLL_FWD: case PLA_SCROLL_FWD_REPEAT: return INPUT_DOWN;
#endif
    default: return 0;
    }
}

static void NewCity(void)
{
    uint8_t terrainType = PreviewTerrain;
    InitGame();
    State.terrainType = terrainType;
    HasCity = true;
    ResetVisibleTileCache();
    UIState.state = InGame;
}

static bool ConfirmReplace(void)
{
    return !HasCity || rb->yesno_pop("Discard current city?");
}

static int MenuCallback(int action, const struct menu_item_ex *this_item,
                        struct gui_synclist *this_list)
{
    (void)this_list;
    int i = (intptr_t)this_item;
    if (action == ACTION_REQUEST_MENUITEM &&
        ((!HasCity && (i == 0 || i == 4 || i == 5 || i == 6 || i == 9 || i == 10)) ||
         (HasCity && i == 11)))
        return ACTION_EXIT_MENUITEM;
    return action;
}

/* Native Rockbox menu, shown at launch and as the pause menu.
 * Returns 0 resume, 1 quit, 2 USB. */
static int PauseMenu(void)
{
    static const struct opt_items terrains[] = {
        {"River", -1}, {"Island", -1}, {"Lake", -1}
    };
    MENUITEM_STRINGLIST(menu, "Microcity", MenuCallback, "Resume Game", "New City",
        "Terrain", "Load City", "Save City", "Tools", "Auto Budget", "Help",
        "Playback Control", "Save and Quit", "Quit without Saving", "Quit");
    int selected = 0, result = -1;
    while (result < 0) {
        switch (rb->do_menu(&menu, &selected, NULL, false)) {
        case 0: result = 0; break;
        case 1:
            if (ConfirmReplace()) { NewCity(); result = 0; }
            break;
        case 2: {
            int t = PreviewTerrain;
            rb->set_option("Terrain", &t, RB_INT, terrains, NUM_TERRAIN_TYPES, NULL);
            PreviewTerrain = t;
            break;
        }
        case 3:
            if (ConfirmReplace() && LoadCity()) result = 0;
            break;
        case 4: SaveCity(); break;
        case 5:
            UIState.state = ShowingToolbar; UIState.selection = UIState.brush;
            result = 0;
            break;
        case 6: {
            bool b = UIState.autoBudget;
            rb->set_bool("Auto Budget", &b);
            UIState.autoBudget = b;
            break;
        }
        case 7:
            rb->splash(0, "Hold directions: move. Select: build/confirm. Double Left: tools. "
                       "Double Right or hold Select+Up: menu. Build a power plant, put roads beside zones, "
                       "balance homes and jobs. Budget sets the tax rate.");
            break;
        case 8: playback_control(NULL); break;
        case 9: if (SaveToDisk()) result = 1; break;
        case 10:
            if (!HasCity || rb->yesno_pop("Quit without saving?")) result = 1;
            break;
        case 11: result = 1; break;
        case MENU_ATTACHED_USB: result = 2; break;
        default: if (HasCity) result = 0; else result = 1; break;
        }
    }
    rb->lcd_set_viewport(NULL);
#if LCD_DEPTH > 1
    rb->lcd_set_background(LCD_BLACK);
#endif
    rb->lcd_clear_display();
    return result;
}

static UIStateStruct GestureBefore;
static uint8_t GestureTerrain, GestureTax;
static int GestureAction;
static long GestureWhen;

static int GestureInput(int a)
{
    if ((a==PLA_LEFT_REPEAT && SuppressRepeat==PLA_LEFT) ||
        (a==PLA_RIGHT_REPEAT && SuppressRepeat==PLA_RIGHT)) return ACTION_NONE;
    if (a==PLA_LEFT || a==PLA_RIGHT) {
        SuppressRepeat=0;
        if (GestureAction==a && UIState.state==GestureBefore.state &&
            (unsigned long)*rb->current_tick-(unsigned long)GestureWhen<=(unsigned)(HZ*3/10)) {
            UIState=GestureBefore; PreviewTerrain=GestureTerrain; State.taxRate=GestureTax;
            if (HasCity) ResetVisibleTileCache();
            GestureAction=0; SuppressRepeat=a;
            return a==PLA_LEFT ? PLA_CANCEL : PLA_EXIT;
        }
        GestureAction=a; GestureWhen=*rb->current_tick;
        GestureBefore=UIState; GestureTerrain=PreviewTerrain; GestureTax=State.taxRate;
    } else if (a!=ACTION_NONE) GestureAction=0;
    return a;
}

enum plugin_status plugin_start(const void *parameter)
{
    (void)parameter;
    enum plugin_status status = PLUGIN_OK;
#if LCD_DEPTH > 1
    unsigned old_foreground = rb->lcd_get_foreground();
    unsigned old_background = rb->lcd_get_background();
#endif
    int old_drawmode = rb->lcd_get_drawmode();
    rb->lcd_set_viewport(NULL);
#if LCD_DEPTH > 1
    rb->lcd_set_background(LCD_BLACK);
#endif
#if LCD_DEPTH >= 16
    fb_data *old_backdrop = rb->lcd_get_backdrop();
    rb->lcd_set_backdrop(NULL);
#endif
    rb->lcd_clear_display();
    backlight_ignore_timeout();
    SelectArmed=SelectHeld=false; GestureAction=SuppressRepeat=0;
#ifdef HAVE_TOUCHSCREEN
    int old_touch=rb->touchscreen_get_mode(); rb->touchscreen_set_mode(TOUCHSCREEN_BUTTON);
#endif
    HasCity = false;
    InitGame();
    PreviewTerrain = State.terrainType;
    {
        int result = PauseMenu();
        if (result) {
            status = result == 2 ? PLUGIN_USB_CONNECTED : PLUGIN_OK;
            goto done;
        }
    }
    DrawInGame(); Draw(); Present();
    long next_frame = *rb->current_tick + MAX(1, HZ / 25);
    for (;;) {
        long now = *rb->current_tick;
        int timeout = TIME_BEFORE(now, next_frame) ? next_frame - now : 0;
        int action = GestureInput(ReadAction(timeout));
        uint8_t input = DirectionInput(action);
        if (action == PLA_SELECT) input = INPUT_B;
        if (action == PLA_CANCEL) input = INPUT_A;
        if (UIState.state==ShowingToolbar || UIState.state==NewCityMenu || UIState.state==BudgetMenu) {
            if (input==INPUT_UP) input=INPUT_LEFT;
            if (input==INPUT_DOWN) input=INPUT_RIGHT;
        }
        if (input) HandleInput(input);
        else if (action == PLA_EXIT) MenuRequest = true;
        else if (rb->default_event_handler(action) == SYS_USB_CONNECTED) {
            status = PLUGIN_USB_CONNECTED;
            break;
        }
        if (MenuRequest) {
            MenuRequest = false;
            int result = PauseMenu();
            if (result) { status = result == 2 ? PLUGIN_USB_CONNECTED : PLUGIN_OK; break; }
            /* A modal replaces the whole image; reconstruct its background. */
            DrawInGame();
            Draw(); Present();
            next_frame = *rb->current_tick + MAX(1, HZ / 25);
        }
        now = *rb->current_tick;
        if (!TIME_BEFORE(now, next_frame)) {
            TickGame(); Present();
            /* Do not run catch-up bursts after disk I/O, splash, or a slow LCD. */
            next_frame = *rb->current_tick + MAX(1, HZ / 25);
        }
    }
done:
#ifdef HAVE_TOUCHSCREEN
    rb->touchscreen_set_mode(old_touch);
#endif
    backlight_use_settings();
    rb->lcd_set_drawmode(old_drawmode);
#if LCD_DEPTH >= 16
    rb->lcd_set_backdrop(old_backdrop);
#endif
#if LCD_DEPTH > 1
    rb->lcd_set_foreground(old_foreground);
    rb->lcd_set_background(old_background);
#endif
    return status;
}

/*
                    GNU GENERAL PUBLIC LICENSE
                       Version 3, 29 June 2007

 Copyright (C) 2007 Free Software Foundation, Inc. <http://fsf.org/>
 Everyone is permitted to copy and distribute verbatim copies
 of this license document, but changing it is not allowed.

                            Preamble

  The GNU General Public License is a free, copyleft license for
software and other kinds of works.

  The licenses for most software and other practical works are designed
to take away your freedom to share and change the works.  By contrast,
the GNU General Public License is intended to guarantee your freedom to
share and change all versions of a program--to make sure it remains free
software for all its users.  We, the Free Software Foundation, use the
GNU General Public License for most of our software; it applies also to
any other work released this way by its authors.  You can apply it to
your programs, too.

  When we speak of free software, we are referring to freedom, not
price.  Our General Public Licenses are designed to make sure that you
have the freedom to distribute copies of free software (and charge for
them if you wish), that you receive source code or can get it if you
want it, that you can change the software or use pieces of it in new
free programs, and that you know you can do these things.

  To protect your rights, we need to prevent others from denying you
these rights or asking you to surrender the rights.  Therefore, you have
certain responsibilities if you distribute copies of the software, or if
you modify it: responsibilities to respect the freedom of others.

  For example, if you distribute copies of such a program, whether
gratis or for a fee, you must pass on to the recipients the same
freedoms that you received.  You must make sure that they, too, receive
or can get the source code.  And you must show them these terms so they
know their rights.

  Developers that use the GNU GPL protect your rights with two steps:
(1) assert copyright on the software, and (2) offer you this License
giving you legal permission to copy, distribute and/or modify it.

  For the developers' and authors' protection, the GPL clearly explains
that there is no warranty for this free software.  For both users' and
authors' sake, the GPL requires that modified versions be marked as
changed, so that their problems will not be attributed erroneously to
authors of previous versions.

  Some devices are designed to deny users access to install or run
modified versions of the software inside them, although the manufacturer
can do so.  This is fundamentally incompatible with the aim of
protecting users' freedom to change the software.  The systematic
pattern of such abuse occurs in the area of products for individuals to
use, which is precisely where it is most unacceptable.  Therefore, we
have designed this version of the GPL to prohibit the practice for those
products.  If such problems arise substantially in other domains, we
stand ready to extend this provision to those domains in future versions
of the GPL, as needed to protect the freedom of users.

  Finally, every program is threatened constantly by software patents.
States should not allow patents to restrict development and use of
software on general-purpose computers, but in those that do, we wish to
avoid the special danger that patents applied to a free program could
make it effectively proprietary.  To prevent this, the GPL assures that
patents cannot be used to render the program non-free.

  The precise terms and conditions for copying, distribution and
modification follow.

                       TERMS AND CONDITIONS

  0. Definitions.

  "This License" refers to version 3 of the GNU General Public License.

  "Copyright" also means copyright-like laws that apply to other kinds of
works, such as semiconductor masks.

  "The Program" refers to any copyrightable work licensed under this
License.  Each licensee is addressed as "you".  "Licensees" and
"recipients" may be individuals or organizations.

  To "modify" a work means to copy from or adapt all or part of the work
in a fashion requiring copyright permission, other than the making of an
exact copy.  The resulting work is called a "modified version" of the
earlier work or a work "based on" the earlier work.

  A "covered work" means either the unmodified Program or a work based
on the Program.

  To "propagate" a work means to do anything with it that, without
permission, would make you directly or secondarily liable for
infringement under applicable copyright law, except executing it on a
computer or modifying a private copy.  Propagation includes copying,
distribution (with or without modification), making available to the
public, and in some countries other activities as well.

  To "convey" a work means any kind of propagation that enables other
parties to make or receive copies.  Mere interaction with a user through
a computer network, with no transfer of a copy, is not conveying.

  An interactive user interface displays "Appropriate Legal Notices"
to the extent that it includes a convenient and prominently visible
feature that (1) displays an appropriate copyright notice, and (2)
tells the user that there is no warranty for the work (except to the
extent that warranties are provided), that licensees may convey the
work under this License, and how to view a copy of this License.  If
the interface presents a list of user commands or options, such as a
menu, a prominent item in the list meets this criterion.

  1. Source Code.

  The "source code" for a work means the preferred form of the work
for making modifications to it.  "Object code" means any non-source
form of a work.

  A "Standard Interface" means an interface that either is an official
standard defined by a recognized standards body, or, in the case of
interfaces specified for a particular programming language, one that
is widely used among developers working in that language.

  The "System Libraries" of an executable work include anything, other
than the work as a whole, that (a) is included in the normal form of
packaging a Major Component, but which is not part of that Major
Component, and (b) serves only to enable use of the work with that
Major Component, or to implement a Standard Interface for which an
implementation is available to the public in source code form.  A
"Major Component", in this context, means a major essential component
(kernel, window system, and so on) of the specific operating system
(if any) on which the executable work runs, or a compiler used to
produce the work, or an object code interpreter used to run it.

  The "Corresponding Source" for a work in object code form means all
the source code needed to generate, install, and (for an executable
work) run the object code and to modify the work, including scripts to
control those activities.  However, it does not include the work's
System Libraries, or general-purpose tools or generally available free
programs which are used unmodified in performing those activities but
which are not part of the work.  For example, Corresponding Source
includes interface definition files associated with source files for
the work, and the source code for shared libraries and dynamically
linked subprograms that the work is specifically designed to require,
such as by intimate data communication or control flow between those
subprograms and other parts of the work.

  The Corresponding Source need not include anything that users
can regenerate automatically from other parts of the Corresponding
Source.

  The Corresponding Source for a work in source code form is that
same work.

  2. Basic Permissions.

  All rights granted under this License are granted for the term of
copyright on the Program, and are irrevocable provided the stated
conditions are met.  This License explicitly affirms your unlimited
permission to run the unmodified Program.  The output from running a
covered work is covered by this License only if the output, given its
content, constitutes a covered work.  This License acknowledges your
rights of fair use or other equivalent, as provided by copyright law.

  You may make, run and propagate covered works that you do not
convey, without conditions so long as your license otherwise remains
in force.  You may convey covered works to others for the sole purpose
of having them make modifications exclusively for you, or provide you
with facilities for running those works, provided that you comply with
the terms of this License in conveying all material for which you do
not control copyright.  Those thus making or running the covered works
for you must do so exclusively on your behalf, under your direction
and control, on terms that prohibit them from making any copies of
your copyrighted material outside their relationship with you.

  Conveying under any other circumstances is permitted solely under
the conditions stated below.  Sublicensing is not allowed; section 10
makes it unnecessary.

  3. Protecting Users' Legal Rights From Anti-Circumvention Law.

  No covered work shall be deemed part of an effective technological
measure under any applicable law fulfilling obligations under article
11 of the WIPO copyright treaty adopted on 20 December 1996, or
similar laws prohibiting or restricting circumvention of such
measures.

  When you convey a covered work, you waive any legal power to forbid
circumvention of technological measures to the extent such circumvention
is effected by exercising rights under this License with respect to
the covered work, and you disclaim any intention to limit operation or
modification of the work as a means of enforcing, against the work's
users, your or third parties' legal rights to forbid circumvention of
technological measures.

  4. Conveying Verbatim Copies.

  You may convey verbatim copies of the Program's source code as you
receive it, in any medium, provided that you conspicuously and
appropriately publish on each copy an appropriate copyright notice;
keep intact all notices stating that this License and any
non-permissive terms added in accord with section 7 apply to the code;
keep intact all notices of the absence of any warranty; and give all
recipients a copy of this License along with the Program.

  You may charge any price or no price for each copy that you convey,
and you may offer support or warranty protection for a fee.

  5. Conveying Modified Source Versions.

  You may convey a work based on the Program, or the modifications to
produce it from the Program, in the form of source code under the
terms of section 4, provided that you also meet all of these conditions:

    a) The work must carry prominent notices stating that you modified
    it, and giving a relevant date.

    b) The work must carry prominent notices stating that it is
    released under this License and any conditions added under section
    7.  This requirement modifies the requirement in section 4 to
    "keep intact all notices".

    c) You must license the entire work, as a whole, under this
    License to anyone who comes into possession of a copy.  This
    License will therefore apply, along with any applicable section 7
    additional terms, to the whole of the work, and all its parts,
    regardless of how they are packaged.  This License gives no
    permission to license the work in any other way, but it does not
    invalidate such permission if you have separately received it.

    d) If the work has interactive user interfaces, each must display
    Appropriate Legal Notices; however, if the Program has interactive
    interfaces that do not display Appropriate Legal Notices, your
    work need not make them do so.

  A compilation of a covered work with other separate and independent
works, which are not by their nature extensions of the covered work,
and which are not combined with it such as to form a larger program,
in or on a volume of a storage or distribution medium, is called an
"aggregate" if the compilation and its resulting copyright are not
used to limit the access or legal rights of the compilation's users
beyond what the individual works permit.  Inclusion of a covered work
in an aggregate does not cause this License to apply to the other
parts of the aggregate.

  6. Conveying Non-Source Forms.

  You may convey a covered work in object code form under the terms
of sections 4 and 5, provided that you also convey the
machine-readable Corresponding Source under the terms of this License,
in one of these ways:

    a) Convey the object code in, or embodied in, a physical product
    (including a physical distribution medium), accompanied by the
    Corresponding Source fixed on a durable physical medium
    customarily used for software interchange.

    b) Convey the object code in, or embodied in, a physical product
    (including a physical distribution medium), accompanied by a
    written offer, valid for at least three years and valid for as
    long as you offer spare parts or customer support for that product
    model, to give anyone who possesses the object code either (1) a
    copy of the Corresponding Source for all the software in the
    product that is covered by this License, on a durable physical
    medium customarily used for software interchange, for a price no
    more than your reasonable cost of physically performing this
    conveying of source, or (2) access to copy the
    Corresponding Source from a network server at no charge.

    c) Convey individual copies of the object code with a copy of the
    written offer to provide the Corresponding Source.  This
    alternative is allowed only occasionally and noncommercially, and
    only if you received the object code with such an offer, in accord
    with subsection 6b.

    d) Convey the object code by offering access from a designated
    place (gratis or for a charge), and offer equivalent access to the
    Corresponding Source in the same way through the same place at no
    further charge.  You need not require recipients to copy the
    Corresponding Source along with the object code.  If the place to
    copy the object code is a network server, the Corresponding Source
    may be on a different server (operated by you or a third party)
    that supports equivalent copying facilities, provided you maintain
    clear directions next to the object code saying where to find the
    Corresponding Source.  Regardless of what server hosts the
    Corresponding Source, you remain obligated to ensure that it is
    available for as long as needed to satisfy these requirements.

    e) Convey the object code using peer-to-peer transmission, provided
    you inform other peers where the object code and Corresponding
    Source of the work are being offered to the general public at no
    charge under subsection 6d.

  A separable portion of the object code, whose source code is excluded
from the Corresponding Source as a System Library, need not be
included in conveying the object code work.

  A "User Product" is either (1) a "consumer product", which means any
tangible personal property which is normally used for personal, family,
or household purposes, or (2) anything designed or sold for incorporation
into a dwelling.  In determining whether a product is a consumer product,
doubtful cases shall be resolved in favor of coverage.  For a particular
product received by a particular user, "normally used" refers to a
typical or common use of that class of product, regardless of the status
of the particular user or of the way in which the particular user
actually uses, or expects or is expected to use, the product.  A product
is a consumer product regardless of whether the product has substantial
commercial, industrial or non-consumer uses, unless such uses represent
the only significant mode of use of the product.

  "Installation Information" for a User Product means any methods,
procedures, authorization keys, or other information required to install
and execute modified versions of a covered work in that User Product from
a modified version of its Corresponding Source.  The information must
suffice to ensure that the continued functioning of the modified object
code is in no case prevented or interfered with solely because
modification has been made.

  If you convey an object code work under this section in, or with, or
specifically for use in, a User Product, and the conveying occurs as
part of a transaction in which the right of possession and use of the
User Product is transferred to the recipient in perpetuity or for a
fixed term (regardless of how the transaction is characterized), the
Corresponding Source conveyed under this section must be accompanied
by the Installation Information.  But this requirement does not apply
if neither you nor any third party retains the ability to install
modified object code on the User Product (for example, the work has
been installed in ROM).

  The requirement to provide Installation Information does not include a
requirement to continue to provide support service, warranty, or updates
for a work that has been modified or installed by the recipient, or for
the User Product in which it has been modified or installed.  Access to a
network may be denied when the modification itself materially and
adversely affects the operation of the network or violates the rules and
protocols for communication across the network.

  Corresponding Source conveyed, and Installation Information provided,
in accord with this section must be in a format that is publicly
documented (and with an implementation available to the public in
source code form), and must require no special password or key for
unpacking, reading or copying.

  7. Additional Terms.

  "Additional permissions" are terms that supplement the terms of this
License by making exceptions from one or more of its conditions.
Additional permissions that are applicable to the entire Program shall
be treated as though they were included in this License, to the extent
that they are valid under applicable law.  If additional permissions
apply only to part of the Program, that part may be used separately
under those permissions, but the entire Program remains governed by
this License without regard to the additional permissions.

  When you convey a copy of a covered work, you may at your option
remove any additional permissions from that copy, or from any part of
it.  (Additional permissions may be written to require their own
removal in certain cases when you modify the work.)  You may place
additional permissions on material, added by you to a covered work,
for which you have or can give appropriate copyright permission.

  Notwithstanding any other provision of this License, for material you
add to a covered work, you may (if authorized by the copyright holders of
that material) supplement the terms of this License with terms:

    a) Disclaiming warranty or limiting liability differently from the
    terms of sections 15 and 16 of this License; or

    b) Requiring preservation of specified reasonable legal notices or
    author attributions in that material or in the Appropriate Legal
    Notices displayed by works containing it; or

    c) Prohibiting misrepresentation of the origin of that material, or
    requiring that modified versions of such material be marked in
    reasonable ways as different from the original version; or

    d) Limiting the use for publicity purposes of names of licensors or
    authors of the material; or

    e) Declining to grant rights under trademark law for use of some
    trade names, trademarks, or service marks; or

    f) Requiring indemnification of licensors and authors of that
    material by anyone who conveys the material (or modified versions of
    it) with contractual assumptions of liability to the recipient, for
    any liability that these contractual assumptions directly impose on
    those licensors and authors.

  All other non-permissive additional terms are considered "further
restrictions" within the meaning of section 10.  If the Program as you
received it, or any part of it, contains a notice stating that it is
governed by this License along with a term that is a further
restriction, you may remove that term.  If a license document contains
a further restriction but permits relicensing or conveying under this
License, you may add to a covered work material governed by the terms
of that license document, provided that the further restriction does
not survive such relicensing or conveying.

  If you add terms to a covered work in accord with this section, you
must place, in the relevant source files, a statement of the
additional terms that apply to those files, or a notice indicating
where to find the applicable terms.

  Additional terms, permissive or non-permissive, may be stated in the
form of a separately written license, or stated as exceptions;
the above requirements apply either way.

  8. Termination.

  You may not propagate or modify a covered work except as expressly
provided under this License.  Any attempt otherwise to propagate or
modify it is void, and will automatically terminate your rights under
this License (including any patent licenses granted under the third
paragraph of section 11).

  However, if you cease all violation of this License, then your
license from a particular copyright holder is reinstated (a)
provisionally, unless and until the copyright holder explicitly and
finally terminates your license, and (b) permanently, if the copyright
holder fails to notify you of the violation by some reasonable means
prior to 60 days after the cessation.

  Moreover, your license from a particular copyright holder is
reinstated permanently if the copyright holder notifies you of the
violation by some reasonable means, this is the first time you have
received notice of violation of this License (for any work) from that
copyright holder, and you cure the violation prior to 30 days after
your receipt of the notice.

  Termination of your rights under this section does not terminate the
licenses of parties who have received copies or rights from you under
this License.  If your rights have been terminated and not permanently
reinstated, you do not qualify to receive new licenses for the same
material under section 10.

  9. Acceptance Not Required for Having Copies.

  You are not required to accept this License in order to receive or
run a copy of the Program.  Ancillary propagation of a covered work
occurring solely as a consequence of using peer-to-peer transmission
to receive a copy likewise does not require acceptance.  However,
nothing other than this License grants you permission to propagate or
modify any covered work.  These actions infringe copyright if you do
not accept this License.  Therefore, by modifying or propagating a
covered work, you indicate your acceptance of this License to do so.

  10. Automatic Licensing of Downstream Recipients.

  Each time you convey a covered work, the recipient automatically
receives a license from the original licensors, to run, modify and
propagate that work, subject to this License.  You are not responsible
for enforcing compliance by third parties with this License.

  An "entity transaction" is a transaction transferring control of an
organization, or substantially all assets of one, or subdividing an
organization, or merging organizations.  If propagation of a covered
work results from an entity transaction, each party to that
transaction who receives a copy of the work also receives whatever
licenses to the work the party's predecessor in interest had or could
give under the previous paragraph, plus a right to possession of the
Corresponding Source of the work from the predecessor in interest, if
the predecessor has it or can get it with reasonable efforts.

  You may not impose any further restrictions on the exercise of the
rights granted or affirmed under this License.  For example, you may
not impose a license fee, royalty, or other charge for exercise of
rights granted under this License, and you may not initiate litigation
(including a cross-claim or counterclaim in a lawsuit) alleging that
any patent claim is infringed by making, using, selling, offering for
sale, or importing the Program or any portion of it.

  11. Patents.

  A "contributor" is a copyright holder who authorizes use under this
License of the Program or a work on which the Program is based.  The
work thus licensed is called the contributor's "contributor version".

  A contributor's "essential patent claims" are all patent claims
owned or controlled by the contributor, whether already acquired or
hereafter acquired, that would be infringed by some manner, permitted
by this License, of making, using, or selling its contributor version,
but do not include claims that would be infringed only as a
consequence of further modification of the contributor version.  For
purposes of this definition, "control" includes the right to grant
patent sublicenses in a manner consistent with the requirements of
this License.

  Each contributor grants you a non-exclusive, worldwide, royalty-free
patent license under the contributor's essential patent claims, to
make, use, sell, offer for sale, import and otherwise run, modify and
propagate the contents of its contributor version.

  In the following three paragraphs, a "patent license" is any express
agreement or commitment, however denominated, not to enforce a patent
(such as an express permission to practice a patent or covenant not to
sue for patent infringement).  To "grant" such a patent license to a
party means to make such an agreement or commitment not to enforce a
patent against the party.

  If you convey a covered work, knowingly relying on a patent license,
and the Corresponding Source of the work is not available for anyone
to copy, free of charge and under the terms of this License, through a
publicly available network server or other readily accessible means,
then you must either (1) cause the Corresponding Source to be so
available, or (2) arrange to deprive yourself of the benefit of the
patent license for this particular work, or (3) arrange, in a manner
consistent with the requirements of this License, to extend the patent
license to downstream recipients.  "Knowingly relying" means you have
actual knowledge that, but for the patent license, your conveying the
covered work in a country, or your recipient's use of the covered work
in a country, would infringe one or more identifiable patents in that
country that you have reason to believe are valid.

  If, pursuant to or in connection with a single transaction or
arrangement, you convey, or propagate by procuring conveyance of, a
covered work, and grant a patent license to some of the parties
receiving the covered work authorizing them to use, propagate, modify
or convey a specific copy of the covered work, then the patent license
you grant is automatically extended to all recipients of the covered
work and works based on it.

  A patent license is "discriminatory" if it does not include within
the scope of its coverage, prohibits the exercise of, or is
conditioned on the non-exercise of one or more of the rights that are
specifically granted under this License.  You may not convey a covered
work if you are a party to an arrangement with a third party that is
in the business of distributing software, under which you make payment
to the third party based on the extent of your activity of conveying
the work, and under which the third party grants, to any of the
parties who would receive the covered work from you, a discriminatory
patent license (a) in connection with copies of the covered work
conveyed by you (or copies made from those copies), or (b) primarily
for and in connection with specific products or compilations that
contain the covered work, unless you entered into that arrangement,
or that patent license was granted, prior to 28 March 2007.

  Nothing in this License shall be construed as excluding or limiting
any implied license or other defenses to infringement that may
otherwise be available to you under applicable patent law.

  12. No Surrender of Others' Freedom.

  If conditions are imposed on you (whether by court order, agreement or
otherwise) that contradict the conditions of this License, they do not
excuse you from the conditions of this License.  If you cannot convey a
covered work so as to satisfy simultaneously your obligations under this
License and any other pertinent obligations, then as a consequence you may
not convey it at all.  For example, if you agree to terms that obligate you
to collect a royalty for further conveying from those to whom you convey
the Program, the only way you could satisfy both those terms and this
License would be to refrain entirely from conveying the Program.

  13. Use with the GNU Affero General Public License.

  Notwithstanding any other provision of this License, you have
permission to link or combine any covered work with a work licensed
under version 3 of the GNU Affero General Public License into a single
combined work, and to convey the resulting work.  The terms of this
License will continue to apply to the part which is the covered work,
but the special requirements of the GNU Affero General Public License,
section 13, concerning interaction through a network will apply to the
combination as such.

  14. Revised Versions of this License.

  The Free Software Foundation may publish revised and/or new versions of
the GNU General Public License from time to time.  Such new versions will
be similar in spirit to the present version, but may differ in detail to
address new problems or concerns.

  Each version is given a distinguishing version number.  If the
Program specifies that a certain numbered version of the GNU General
Public License "or any later version" applies to it, you have the
option of following the terms and conditions either of that numbered
version or of any later version published by the Free Software
Foundation.  If the Program does not specify a version number of the
GNU General Public License, you may choose any version ever published
by the Free Software Foundation.

  If the Program specifies that a proxy can decide which future
versions of the GNU General Public License can be used, that proxy's
public statement of acceptance of a version permanently authorizes you
to choose that version for the Program.

  Later license versions may give you additional or different
permissions.  However, no additional obligations are imposed on any
author or copyright holder as a result of your choosing to follow a
later version.

  15. Disclaimer of Warranty.

  THERE IS NO WARRANTY FOR THE PROGRAM, TO THE EXTENT PERMITTED BY
APPLICABLE LAW.  EXCEPT WHEN OTHERWISE STATED IN WRITING THE COPYRIGHT
HOLDERS AND/OR OTHER PARTIES PROVIDE THE PROGRAM "AS IS" WITHOUT WARRANTY
OF ANY KIND, EITHER EXPRESSED OR IMPLIED, INCLUDING, BUT NOT LIMITED TO,
THE IMPLIED WARRANTIES OF MERCHANTABILITY AND FITNESS FOR A PARTICULAR
PURPOSE.  THE ENTIRE RISK AS TO THE QUALITY AND PERFORMANCE OF THE PROGRAM
IS WITH YOU.  SHOULD THE PROGRAM PROVE DEFECTIVE, YOU ASSUME THE COST OF
ALL NECESSARY SERVICING, REPAIR OR CORRECTION.

  16. Limitation of Liability.

  IN NO EVENT UNLESS REQUIRED BY APPLICABLE LAW OR AGREED TO IN WRITING
WILL ANY COPYRIGHT HOLDER, OR ANY OTHER PARTY WHO MODIFIES AND/OR CONVEYS
THE PROGRAM AS PERMITTED ABOVE, BE LIABLE TO YOU FOR DAMAGES, INCLUDING ANY
GENERAL, SPECIAL, INCIDENTAL OR CONSEQUENTIAL DAMAGES ARISING OUT OF THE
USE OR INABILITY TO USE THE PROGRAM (INCLUDING BUT NOT LIMITED TO LOSS OF
DATA OR DATA BEING RENDERED INACCURATE OR LOSSES SUSTAINED BY YOU OR THIRD
PARTIES OR A FAILURE OF THE PROGRAM TO OPERATE WITH ANY OTHER PROGRAMS),
EVEN IF SUCH HOLDER OR OTHER PARTY HAS BEEN ADVISED OF THE POSSIBILITY OF
SUCH DAMAGES.

  17. Interpretation of Sections 15 and 16.

  If the disclaimer of warranty and limitation of liability provided
above cannot be given local legal effect according to their terms,
reviewing courts shall apply local law that most closely approximates
an absolute waiver of all civil liability in connection with the
Program, unless a warranty or assumption of liability accompanies a
copy of the Program in return for a fee.

                     END OF TERMS AND CONDITIONS

            How to Apply These Terms to Your New Programs

  If you develop a new program, and you want it to be of the greatest
possible use to the public, the best way to achieve this is to make it
free software which everyone can redistribute and change under these terms.

  To do so, attach the following notices to the program.  It is safest
to attach them to the start of each source file to most effectively
state the exclusion of warranty; and each file should have at least
the "copyright" line and a pointer to where the full notice is found.

    <one line to give the program's name and a brief idea of what it does.>
    Copyright (C) <year>  <name of author>

    This program is free software: you can redistribute it and/or modify
    it under the terms of the GNU General Public License as published by
    the Free Software Foundation, either version 3 of the License, or
    (at your option) any later version.

    This program is distributed in the hope that it will be useful,
    but WITHOUT ANY WARRANTY; without even the implied warranty of
    MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
    GNU General Public License for more details.

    You should have received a copy of the GNU General Public License
    along with this program.  If not, see <http://www.gnu.org/licenses/>.

Also add information on how to contact you by electronic and paper mail.

  If the program does terminal interaction, make it output a short
notice like this when it starts in an interactive mode:

    <program>  Copyright (C) <year>  <name of author>
    This program comes with ABSOLUTELY NO WARRANTY; for details type `show w'.
    This is free software, and you are welcome to redistribute it
    under certain conditions; type `show c' for details.

The hypothetical commands `show w' and `show c' should show the appropriate
parts of the General Public License.  Of course, your program's commands
might be different; for a GUI interface, you would use an "about box".

  You should also get your employer (if you work as a programmer) or school,
if any, to sign a "copyright disclaimer" for the program, if necessary.
For more information on this, and how to apply and follow the GNU GPL, see
<http://www.gnu.org/licenses/>.

  The GNU General Public License does not permit incorporating your program
into proprietary programs.  If your program is a subroutine library, you
may consider it more useful to permit linking proprietary applications with
the library.  If this is what you want to do, use the GNU Lesser General
Public License instead of this License.  But first, please read
<http://www.gnu.org/philosophy/why-not-lgpl.html>.

*/
