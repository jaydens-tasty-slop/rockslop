/* Rockcraft -- a small-RAM Rockbox port of The Science Elf's Blocks-TI-84.
 * Upstream: https://github.com/TheScienceElf/Blocks-TI-84
 * Based on commit b515543c69a72ab995a31461a96dc93e6039261b (MIT).
 * Rockbox adaptation, 2026. This source is distributed under the MIT license.
 *
 * INSTALL: Copy this one file to apps/plugins/rockcraft.c. Add rockcraft.c
 * to apps/plugins/SOURCES inside an LCD_WIDTH >= 96 && LCD_HEIGHT
 * >= 64 guard. Build with your target's normal Rockbox toolchain.
 * No external artwork, heap, audio buffer, threads, floats or FPU required.
 *
 * Bitmap LCDs >=96x64: scales 16x15-pixel isometric blocks with the display.
 * ROCKCRAFT_SCALE defaults to max(1,min(LCD_WIDTH/96,LCD_HEIGHT/96)).
 * Menus/help scroll and the material grid pages to fit. Keeps all 24 materials,
 * the original 48 x 48 x 16 world, terrain/trees/ores, shadows and water tint.
 * This is the upstream creative world editor, with no survival simulation.
 *
 * MEMORY: world = 23,040 bytes (5 bits/block); renderer = an 8 * ROCKCRAFT_SCALE pixel span.
 * No private framebuffer, world-sized visibility/shadow arrays or unpacked
 * texture copy. Artwork is 3,312 bytes of 6-bit texels plus 680 palette/mask
 * bytes. Const data AND code count toward plugin RAM on non-XIP targets.
 * Rockbox still needs its own framebuffer: 40,960 bytes at 128x160 RGB565,
 * 5,120 bytes at 2 bpp, or 2,560 bytes at 1 bpp, plus any driver buffers.
 * Shadows are traced only for visible triangles. Repaint only after input;
 * this favors low RAM over upstream's cached scrolling speed.
 *
 * OPTIONS (before includes, or compiler -D):
 *   ROCKCRAFT_COLOR=1 (default on HAVE_LCD_COLOR): native color.
 *   ROCKCRAFT_COLOR=0: grayscale/dither; works on mono/gray/color LCDs.
 *   ROCKCRAFT_SHADOWS=0: omit cast shadows for slower CPUs (default 1).
 * Color cannot remove a framebuffer allocated by the Rockbox LCD driver.
 *
 * CONTROLS (only D-pad and center; long-center remains reserved):
 *   Directions: move along X/Z. Up=+X, down=-X, left=+Z, right=-Z.
 *   Hold a direction to keep moving. Short center: place/remove immediately
 *     on release. Place into air/water; otherwise remove the block.
 *   Double Up/Down: raise/lower the cursor. Double Left: material picker.
 *   Keep the second Up/Down press held to climb/descend continuously.
 *   Double Right: menu. The first tap's step is reversed for a recognized
 *     double tap, so shortcuts do not leave an unintended movement behind.
 *   Double-tap interval: 300 ms (override ROCKCRAFT_DOUBLE_TICKS, in ticks).
 *   Cancel opens blocks; Exit opens menu on targets with those actions.
 *     A repeat/hold or intervening action cancels double-tap recognition.
 *   Menu > Move up/down: toggle height mode, then up/down change Y while
 *     left/right still change Z. Menu > Return to ground restores X/Z.
 *   Menu: up/down choose, center/right confirm, left backs out.
 *   Materials: D-pad navigates the grid; center chooses. The Back row below
 *     the grid cancels (also reachable by pressing up from its first row).
 *   Long center/repeat and its release have NO game action in any screen.
 * Camera follows the cursor. All gestures work without button combinations.
 * Standard targets use pluginlib_actions, including wheels/remotes and 3x3
 * touchscreen buttons. Wheel detents move/scroll, never count as double taps.
 * YP3_PAD has an explicit five-button context; PORT_CENTER_BUTTON overrides
 * its center mask if needed. Long-center remains unbound in the game.
 * ROCKCRAFT_RAW_INPUT optionally bypasses pluginlib on custom boards; then
 * ROCKCRAFT_UP/DOWN/LEFT/RIGHT/CENTER override the five raw BUTTON_* masks.
 * Device-reserved actions stay with the Rockbox driver/default_event_handler.
 *
 * SAVES: five slots, rockcraft-a.bin ... rockcraft-e.bin in
 * PLUGIN_GAMES_DATA_DIR; versioned packed format with FNV-1a integrity check.
 * Saves use a temporary file and rename; failed writes leave the old save.
 * Explicit Save / Save and quit. USB exits without saving; save first.
 * TI AppVar worlds are not directly compatible. No undo buffer is allocated.
 * Trial port: compile with your real target to obtain its exact .rock RAM
 * size and validate input/LCD speed. Native simulator size is only a guide.
 */

/*
MIT License

Copyright (c) 2023 The Science Elf

Permission is hereby granted, free of charge, to any person obtaining a copy
of this software and associated documentation files (the "Software"), to deal
in the Software without restriction, including without limitation the rights
to use, copy, modify, merge, publish, distribute, sublicense, and/or sell
copies of the Software, and to permit persons to whom the Software is
furnished to do so, subject to the following conditions:

The above copyright notice and this permission notice shall be included in all
copies or substantial portions of the Software.

THE SOFTWARE IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND, EXPRESS OR
IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF MERCHANTABILITY,
FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT. IN NO EVENT SHALL THE
AUTHORS OR COPYRIGHT HOLDERS BE LIABLE FOR ANY CLAIM, DAMAGES OR OTHER
LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE, ARISING FROM,
OUT OF OR IN CONNECTION WITH THE SOFTWARE OR THE USE OR OTHER DEALINGS IN THE
SOFTWARE.
*/

#include "plugin.h"
#include "lib/helper.h"
#include "lib/playback_control.h"
#include "lib/pluginlib_actions.h"

#ifndef ROCKCRAFT_COLOR
#ifdef HAVE_LCD_COLOR
#define ROCKCRAFT_COLOR 1
#else
#define ROCKCRAFT_COLOR 0
#endif
#endif
#if ROCKCRAFT_COLOR && !defined(HAVE_LCD_COLOR)
#error "ROCKCRAFT_COLOR=1 requires HAVE_LCD_COLOR"
#endif
#ifndef ROCKCRAFT_SHADOWS
#define ROCKCRAFT_SHADOWS 1
#endif
#if LCD_WIDTH < 96 || LCD_HEIGHT < 64
#error "Rockcraft needs a bitmap LCD of at least 96 x 64"
#endif

#define WORLD_SIZE 48
#define WORLD_HEIGHT 16
#define WORLD_BYTES (WORLD_SIZE * WORLD_SIZE * WORLD_HEIGHT * 5 / 8)
#define ROW_COUNT 127
#define MAX_DEPTH 109
#ifndef ROCKCRAFT_SCALE
#define ROCKCRAFT_SCALE MAX(1, MIN(LCD_WIDTH / 96, LCD_HEIGHT / 96))
#endif
#define RB_WIDTH (LCD_WIDTH / ROCKCRAFT_SCALE)
#define VIEW_HEIGHT ((LCD_HEIGHT - 16) / ROCKCRAFT_SCALE)
enum { AIR, WATER, STONE, GRASS, DIRT, COBBLE, PLANKS, BRICKS, SLABS,
       WOOD, LEAVES, SAND, BOOKS, TNT, CRAFTING, FURNACE, JUKEBOX,
       SPONGE, GRAVEL, MOSS, COAL_ORE, IRON_ORE, BEDROCK, IRON, GOLD };
static uint8_t world_bits[WORLD_BYTES];
static struct { int x, y, z; uint8_t material; bool height; } player;
static uint32_t rng = 1;
static bool usb, dirty;
static int slot;

#ifdef ROCKCRAFT_RAW_INPUT
/* Override these five raw button masks for a new target. No extra keys,
 * button combinations or game bindings for long-center are required. */
#ifndef ROCKCRAFT_UP
#define ROCKCRAFT_UP BUTTON_UP
#endif
#ifndef ROCKCRAFT_DOWN
#define ROCKCRAFT_DOWN BUTTON_DOWN
#endif
#ifndef ROCKCRAFT_LEFT
#define ROCKCRAFT_LEFT BUTTON_LEFT
#endif
#ifndef ROCKCRAFT_RIGHT
#define ROCKCRAFT_RIGHT BUTTON_RIGHT
#endif
#ifndef ROCKCRAFT_CENTER
#if defined(BUTTON_SELECT)
#define ROCKCRAFT_CENTER BUTTON_SELECT
#elif defined(BUTTON_PLAY)
#define ROCKCRAFT_CENTER BUTTON_PLAY
#elif defined(BUTTON_OK)
#define ROCKCRAFT_CENTER BUTTON_OK
#else
#error "Define ROCKCRAFT_CENTER to your center button mask"
#endif
#endif
#define CONTROL_MASK (ROCKCRAFT_UP|ROCKCRAFT_DOWN|ROCKCRAFT_LEFT|ROCKCRAFT_RIGHT|ROCKCRAFT_CENTER)
#endif
enum { INPUT_NONE, INPUT_UP, INPUT_DOWN, INPUT_LEFT, INPUT_RIGHT, INPUT_TAP,
       INPUT_DOUBLE_UP, INPUT_DOUBLE_DOWN, INPUT_DOUBLE_LEFT, INPUT_DOUBLE_RIGHT,
       INPUT_BACK, INPUT_MENU,
       INPUT_REPEAT=16, INPUT_RELEASE=32 };
static struct { unsigned held, suppress; long since; bool used; } input;
static struct { long when; uint8_t direction, phase, x,y,z; } gesture;

#ifdef ROCKCRAFT_RAW_INPUT
static int direction(unsigned buttons)
{
    return buttons & ROCKCRAFT_UP ? INPUT_UP :
           buttons & ROCKCRAFT_DOWN ? INPUT_DOWN :
           buttons & ROCKCRAFT_LEFT ? INPUT_LEFT :
           buttons & ROCKCRAFT_RIGHT ? INPUT_RIGHT : INPUT_NONE;
}

static int read_input(void)
{
    int b=rb->button_get_w_tmo(HZ/30 > 0 ? HZ/30 : 1);
    if (b==BUTTON_NONE) return INPUT_NONE;
    if (rb->default_event_handler(b)==SYS_USB_CONNECTED) {
        usb=true; return INPUT_NONE;
    }
    unsigned buttons=b & CONTROL_MASK;
    if (!buttons) return INPUT_NONE;
    if (b & BUTTON_REL) {
        bool center=(input.held & ROCKCRAFT_CENTER) && (buttons & ROCKCRAFT_CENTER);
        input.held &= ~buttons;
        if (buttons & input.suppress) { input.suppress &= ~buttons; return INPUT_NONE; }
        if (!center) {
            int dir=direction(buttons);
            return dir ? dir|INPUT_RELEASE : INPUT_NONE;
        }
        if (input.used) return INPUT_NONE;
        return ((unsigned long)*rb->current_tick-(unsigned long)input.since) >= (unsigned)(HZ*3/5)
            ? INPUT_NONE : INPUT_TAP;
    }
    bool pressed_center=(buttons & ROCKCRAFT_CENTER) && !(input.held & ROCKCRAFT_CENTER);
    input.held=buttons;
    if (buttons & input.suppress) return INPUT_NONE;
    if (pressed_center) { input.since=*rb->current_tick; input.used=false; }
    int dir=direction(buttons);
    if (buttons & ROCKCRAFT_CENTER) {
        /* Repeat/long-center belongs to the device, including its release.
         * Also suppress accidental clicks from unsupported button combos. */
        if (dir || (b & BUTTON_REPEAT)) input.used=true;
        return INPUT_NONE;
    }
    if (dir) return dir | ((b & BUTTON_REPEAT) ? INPUT_REPEAT : 0);
    return INPUT_NONE;
}

#else
/* YP3: only four directions and center. Long-center is device-reserved.
 * Override PORT_CENTER_BUTTON if the board header uses a different name. */
#if defined(YP3_PAD) && CONFIG_KEYPAD == YP3_PAD
#ifndef PORT_CENTER_BUTTON
#if defined(BUTTON_SELECT)
#define PORT_CENTER_BUTTON BUTTON_SELECT
#elif defined(BUTTON_PLAY)
#define PORT_CENTER_BUTTON BUTTON_PLAY
#elif defined(BUTTON_CENTER)
#define PORT_CENTER_BUTTON BUTTON_CENTER
#elif defined(BUTTON_OK)
#define PORT_CENTER_BUTTON BUTTON_OK
#elif defined(BUTTON_PLAYPAUSE)
#define PORT_CENTER_BUTTON BUTTON_PLAYPAUSE
#else
#error "Define PORT_CENTER_BUTTON to the YP3 center button raw mask"
#endif
#endif
static const struct button_mapping yp3_context[]={
    {PLA_UP,BUTTON_UP,BUTTON_NONE}, {PLA_DOWN,BUTTON_DOWN,BUTTON_NONE},
    {PLA_LEFT,BUTTON_LEFT,BUTTON_NONE}, {PLA_RIGHT,BUTTON_RIGHT,BUTTON_NONE},
    {PLA_UP_REPEAT,BUTTON_UP|BUTTON_REPEAT,BUTTON_NONE},
    {PLA_DOWN_REPEAT,BUTTON_DOWN|BUTTON_REPEAT,BUTTON_NONE},
    {PLA_LEFT_REPEAT,BUTTON_LEFT|BUTTON_REPEAT,BUTTON_NONE},
    {PLA_RIGHT_REPEAT,BUTTON_RIGHT|BUTTON_REPEAT,BUTTON_NONE},
    {PLA_SELECT,PORT_CENTER_BUTTON,BUTTON_NONE},
    {PLA_SELECT_REL,PORT_CENTER_BUTTON|BUTTON_REL,BUTTON_NONE},
    {PLA_SELECT_REPEAT,PORT_CENTER_BUTTON|BUTTON_REPEAT,BUTTON_NONE},
    LAST_ITEM_IN_LIST
};
#define PORT_MAIN_CONTEXT yp3_context
#else
#define PORT_MAIN_CONTEXT pla_main_ctx
#endif

#ifdef HAVE_BLUETOOTH_HID
/* Game controller: A taps, B cancels (block picker), Options opens the menu */
static const struct button_mapping pad_context[]={
    {PLA_SELECT,BUTTON_PAD_A,BUTTON_NONE},
    {PLA_SELECT_REL,BUTTON_PAD_A|BUTTON_REL,BUTTON_NONE},
    {PLA_SELECT_REPEAT,BUTTON_PAD_A|BUTTON_REPEAT,BUTTON_NONE},
    {PLA_CANCEL,BUTTON_PAD_B,BUTTON_NONE},
    {PLA_EXIT,BUTTON_PAD_MENU,BUTTON_NONE},
    {PLA_EXIT,BUTTON_PAD_HOME,BUTTON_NONE},
    LAST_ITEM_IN_LIST__NEXTLIST(CONTEXT_PLUGIN)
};
#endif

#ifdef HAVE_BLUETOOTH_HID
static const struct button_mapping *contexts[]={pad_context, PORT_MAIN_CONTEXT,
#else
static const struct button_mapping *contexts[]={PORT_MAIN_CONTEXT,
#endif
#ifdef HAVE_REMOTE_LCD
    pla_remote_ctx,
#endif
};
static int read_input(void)
{
    int a=pluginlib_getaction(HZ/30 > 0 ? HZ/30 : 1,contexts,ARRAYLEN(contexts));
    if (rb->default_event_handler(a)==SYS_USB_CONNECTED) { usb=true; return INPUT_NONE; }
    if (a==PLA_SELECT) { input.held=1; input.used=false; input.since=*rb->current_tick; input.suppress=0; return INPUT_NONE; }
    if (a==PLA_SELECT_REPEAT) { input.held=0; input.used=true; return INPUT_NONE; }
    if (a==PLA_SELECT_REL) {
        bool click=input.held && !input.used &&
            (unsigned long)*rb->current_tick-(unsigned long)input.since < (unsigned)(HZ*3/5);
        input.held=0; return click ? INPUT_TAP : INPUT_NONE;
    }
    if (a==PLA_CANCEL) return INPUT_BACK;
    if (a==PLA_EXIT) return INPUT_MENU;
    int d=INPUT_NONE; bool repeat=false;
    switch (a) {
    case PLA_UP: d=INPUT_UP; break;
    case PLA_DOWN: d=INPUT_DOWN; break;
    case PLA_LEFT: d=INPUT_LEFT; break;
    case PLA_RIGHT: d=INPUT_RIGHT; break;
    case PLA_UP_REPEAT: d=INPUT_UP; repeat=true; break;
    case PLA_DOWN_REPEAT: d=INPUT_DOWN; repeat=true; break;
    case PLA_LEFT_REPEAT: d=INPUT_LEFT; repeat=true; break;
    case PLA_RIGHT_REPEAT: d=INPUT_RIGHT; repeat=true; break;
#ifdef HAVE_SCROLLWHEEL
    /* Wheel detents never count as double taps. Use Menu/Play for vertical
     * double taps on iPods; the wheel is convenient for lists and movement. */
    case PLA_SCROLL_BACK: case PLA_SCROLL_BACK_REPEAT: d=INPUT_UP; repeat=true; break;
    case PLA_SCROLL_FWD: case PLA_SCROLL_FWD_REPEAT: d=INPUT_DOWN; repeat=true; break;
#endif
    }
    if (!d) return INPUT_NONE;
    /* Standard keymaps often omit release after Select repeat. A following
     * direction must still work, even if the reserved hold ate its release. */
    if (input.held) { input.held=0; input.used=true; }
    if (repeat && input.suppress==(unsigned)d) return INPUT_NONE;
    if (!repeat) input.suppress=0;
    return d | (repeat ? INPUT_REPEAT : 0);
}
#endif

/* Menus retain ordinary D-pad navigation. Gestures apply only to the world. */
static int action(void)
{
    int a=read_input();
    return (a & INPUT_RELEASE) ? INPUT_NONE : a & ~INPUT_REPEAT;
}

#ifndef ROCKCRAFT_DOUBLE_TICKS
#define ROCKCRAFT_DOUBLE_TICKS (HZ*3/10)
#endif

/* A first tap moves immediately. A second matching tap within 300 ms restores
 * the first tap's cursor position before running its shortcut. Holding a
 * direction repeats movement and cancels double-tap eligibility. No world
 * edits are undone: any intervening edit/different direction cancels it. */
static int game_action(void)
{
#ifdef PORT_CENTER_BUTTON
    /* Common pause gesture: hold Select+Up for 0.5 s. Select alone acts only
     * on a click, so the chord is free; its release must not click. */
    static unsigned long chord_since; static bool chord_done;
    if ((rb->button_status()&(PORT_CENTER_BUTTON|BUTTON_UP))==(PORT_CENTER_BUTTON|BUTTON_UP)) {
        if (!chord_since) chord_since=*rb->current_tick|1;
        else if (!chord_done && *rb->current_tick-chord_since>=(unsigned long)(HZ/2)) {
            chord_done=true; input.held=0; input.used=true; input.suppress=INPUT_UP;
            gesture.phase=0; return INPUT_MENU;
        }
    } else { chord_since=0; chord_done=false; }
#endif
    int a=read_input(), dir=a & ~(INPUT_REPEAT|INPUT_RELEASE);
    unsigned long elapsed=(unsigned long)*rb->current_tick-(unsigned long)gesture.when;
    if (dir>=INPUT_UP && dir<=INPUT_RIGHT) {
        if (a & INPUT_RELEASE) {
            if (gesture.phase==1 && gesture.direction==dir && elapsed<ROCKCRAFT_DOUBLE_TICKS) {
                gesture.phase=2; gesture.when=*rb->current_tick;
            } else gesture.phase=0;
            return INPUT_NONE;
        }
        if (a & INPUT_REPEAT) {
            if (gesture.phase==3 && gesture.direction==dir)
                return INPUT_DOUBLE_UP+dir-INPUT_UP;
            gesture.phase=0; return dir;
        }
        if (gesture.phase==2 && gesture.direction==dir && elapsed<=ROCKCRAFT_DOUBLE_TICKS) {
            #ifdef ROCKCRAFT_RAW_INPUT
            static const unsigned masks[]={ROCKCRAFT_UP,ROCKCRAFT_DOWN,ROCKCRAFT_LEFT,ROCKCRAFT_RIGHT};
#endif
            player.x=gesture.x; player.y=gesture.y; player.z=gesture.z;
            /* Vertical shortcuts latch until release: hold the second tap
             * to climb rapidly. Menu/picker shortcuts swallow their held
             * key so its repeats cannot select an unintended menu entry. */
            if (dir<=INPUT_DOWN) gesture.phase=3;
            else {
                gesture.phase=0;
#ifdef ROCKCRAFT_RAW_INPUT
                input.suppress=masks[dir-INPUT_UP];
#else
                input.suppress=dir;
#endif
            }
            return INPUT_DOUBLE_UP+dir-INPUT_UP;
        }
        gesture.direction=dir;
#ifdef ROCKCRAFT_RAW_INPUT
        gesture.phase=1;
#else
        gesture.phase=2; /* PLA directions have press/repeat but no release. */
#endif
        gesture.when=*rb->current_tick;
        gesture.x=player.x; gesture.y=player.y; gesture.z=player.z;
        return dir;
    }
    if (a==INPUT_TAP || a==INPUT_BACK || a==INPUT_MENU) gesture.phase=0;
    return a;
}

static const uint8_t block_tex[23 * 6][24] = {
    {0x85, 0x50, 0x8, 0x85, 0x51, 0x18, 0x87, 0x51, 0x18, 0x85, 0x70, 0x14, 0x86, 0x51, 0x18, 0x47, 0x51, 0x14, 0x82, 0x20, 0x18, 0x42, 0x51, 0x14},
    {0x42, 0x21, 0x14, 0x86, 0x51, 0x18, 0x42, 0x51, 0x8, 0x82, 0x20, 0x14, 0x82, 0x70, 0x14, 0x82, 0x51, 0x18, 0x82, 0x71, 0x18, 0x85, 0x20, 0x14},
    {0x85, 0x70, 0x18, 0x42, 0x51, 0x18, 0x46, 0x61, 0x1c, 0x82, 0x71, 0x8, 0x85, 0x60, 0x8, 0x45, 0x21, 0x14, 0x86, 0x21, 0x8, 0x86, 0x51, 0x18},
    {0x82, 0x20, 0x8, 0x42, 0x61, 0x8, 0x46, 0x71, 0x8, 0x42, 0x51, 0x8, 0xc6, 0x21, 0x8, 0x82, 0x50, 0x8, 0x82, 0x20, 0x14, 0x85, 0x21, 0x14},
    {0x82, 0x20, 0x18, 0x85, 0x71, 0x8, 0x85, 0x51, 0x8, 0x85, 0x60, 0x14, 0x42, 0x51, 0x8, 0x45, 0x21, 0x14, 0xc2, 0x21, 0x8, 0x45, 0x51, 0x8},
    {0x42, 0x21, 0x1c, 0x86, 0x51, 0x14, 0x86, 0x61, 0x8, 0x85, 0x70, 0x18, 0x85, 0x20, 0x14, 0x82, 0x51, 0x18, 0x85, 0x21, 0x18, 0x85, 0x21, 0x14},
    {0xc, 0xb2, 0x28, 0x4c, 0xb3, 0x28, 0xcc, 0xc2, 0x30, 0x4b, 0xd3, 0x28, 0x87, 0xa2, 0x34, 0xb, 0xc3, 0x30, 0x8d, 0xb0, 0x30, 0x8c, 0xb2, 0x2c},
    {0x8, 0xd2, 0xb4, 0x2d, 0xc2, 0x2c, 0x8, 0x82, 0x20, 0xa, 0xc3, 0x30, 0x48, 0x8b, 0x24, 0xb, 0xb3, 0x30, 0x4d, 0xb3, 0x30, 0xc, 0xc3, 0x2c},
    {0x8, 0x82, 0xb4, 0x4d, 0x83, 0x20, 0x8, 0xc2, 0x30, 0x48, 0x8b, 0x34, 0xd, 0xc3, 0x2c, 0x4d, 0xa3, 0x2c, 0xc, 0xc3, 0x30, 0xb, 0xc3, 0x2c},
    {0x6d, 0xb3, 0x2c, 0x2, 0xa3, 0x28, 0x4c, 0xd3, 0x2c, 0x4b, 0xa3, 0x30, 0x8c, 0xc2, 0x30, 0xb, 0xb3, 0x2c, 0xc, 0xc3, 0x30, 0x8c, 0xb0, 0x28},
    {0x49, 0x8b, 0x24, 0x48, 0x9b, 0x20, 0x49, 0x8b, 0x20, 0x49, 0xdb, 0x26, 0x6d, 0xd2, 0xb6, 0x49, 0x9b, 0x24, 0x48, 0xdb, 0x26, 0x2d, 0x92, 0xb4},
    {0x8, 0x82, 0x20, 0x49, 0x82, 0x24, 0x9, 0xd2, 0x22, 0x49, 0x82, 0x24, 0x48, 0x82, 0x24, 0x48, 0x92, 0x20, 0x8, 0x92, 0x20, 0x6d, 0x82, 0x24},
    {0x8c, 0xb2, 0x28, 0x4c, 0xb3, 0x28, 0xcc, 0xc2, 0x30, 0x4b, 0xc3, 0x28, 0x87, 0xa2, 0x34, 0xb, 0xc3, 0x30, 0x8d, 0xb0, 0x30, 0x8c, 0xb2, 0x2c},
    {0xcc, 0xb2, 0x30, 0xcc, 0xc2, 0x2c, 0xb, 0xc3, 0x34, 0xa, 0xc3, 0x30, 0xb, 0xc3, 0x30, 0xb, 0xb3, 0x30, 0xd, 0xb3, 0x30, 0xc, 0xc3, 0x2c},
    {0x4c, 0xc3, 0x2c, 0xcd, 0xc2, 0x8, 0xa, 0xc3, 0x30, 0x4a, 0xa3, 0x30, 0xb, 0xc3, 0x2c, 0x4d, 0xa3, 0x2c, 0xc, 0xc3, 0x30, 0xb, 0xc3, 0x2c},
    {0x8a, 0xb2, 0x2c, 0x2, 0xa3, 0x28, 0x4c, 0xd3, 0x2c, 0x4b, 0xa3, 0x30, 0x8c, 0xc2, 0x30, 0xb, 0xb3, 0x2c, 0xc, 0xc3, 0x30, 0x8c, 0xb0, 0x28},
    {0x8b, 0xa2, 0x28, 0xcd, 0xb2, 0x2c, 0xb, 0xa3, 0x8, 0xcb, 0xb2, 0x2c, 0x8b, 0xd2, 0x30, 0xb, 0xc3, 0x28, 0x4b, 0xb3, 0x30, 0xd, 0xc3, 0x30},
    {0xcb, 0xc2, 0x28, 0xcb, 0xb2, 0x30, 0x8a, 0xa2, 0x34, 0x8c, 0xc2, 0x30, 0x4b, 0xb3, 0x30, 0xcc, 0xb2, 0x30, 0x4c, 0xc3, 0x2c, 0x4a, 0xa3, 0x28},
    {0x10, 0x4, 0x3d, 0xc7, 0x53, 0x38, 0xe, 0x24, 0x8, 0x5, 0xf8, 0x1c, 0x86, 0x0, 0xd, 0xa1, 0x70, 0x38, 0x8f, 0xf1, 0x8, 0x6, 0x4, 0x82},
    {0x8e, 0x53, 0x8, 0xe1, 0x51, 0x40, 0x8e, 0x3, 0x39, 0x82, 0x50, 0x8, 0xa0, 0x61, 0x38, 0x6, 0xf4, 0x80, 0xcf, 0x3, 0x15, 0xc2, 0xe1, 0x80},
    {0x42, 0x1, 0x9, 0xa0, 0x63, 0x38, 0x21, 0x8, 0x85, 0xce, 0x1, 0x19, 0x50, 0x51, 0x1c, 0x8e, 0x70, 0x80, 0xa0, 0xf0, 0x18, 0x10, 0x24, 0x8},
    {0x50, 0xe8, 0x8, 0x7, 0x24, 0x84, 0x8e, 0x23, 0x80, 0x82, 0x23, 0x8, 0xe0, 0x23, 0x80, 0xd0, 0x3, 0x42, 0x10, 0xe4, 0x14, 0x2, 0x58, 0x14},
    {0x5, 0x24, 0x8, 0x2, 0x4, 0x41, 0x10, 0x4, 0x1d, 0x45, 0x21, 0x80, 0x82, 0x0, 0x1e, 0x90, 0xe0, 0x1c, 0x82, 0x0, 0x41, 0x83, 0x3, 0x9},
    {0x8e, 0x3, 0x41, 0xd0, 0x21, 0x8, 0x42, 0x28, 0x38, 0xd0, 0x31, 0x3c, 0x20, 0x8, 0x3a, 0x6, 0x24, 0x14, 0xd0, 0x3, 0x41, 0xce, 0x20, 0x40},
    {0x56, 0x64, 0x59, 0x92, 0x64, 0x49, 0x92, 0x64, 0x45, 0x96, 0x14, 0x45, 0x96, 0x14, 0x45, 0x56, 0x14, 0x49, 0x96, 0x64, 0x49, 0x52, 0xb4, 0x47},
    {0x91, 0x64, 0x49, 0x52, 0x24, 0x49, 0x96, 0x24, 0x45, 0x56, 0x24, 0x45, 0x56, 0x24, 0x45, 0x52, 0x64, 0x45, 0x92, 0x64, 0x49, 0x92, 0x24, 0x45},
    {0x51, 0x24, 0x49, 0x96, 0x25, 0x49, 0x91, 0x25, 0x49, 0x91, 0x24, 0x59, 0x91, 0x14, 0x59, 0x52, 0x24, 0x59, 0x91, 0x14, 0x49, 0x92, 0x25, 0x49},
    {0x91, 0x15, 0x59, 0x91, 0x15, 0x59, 0x91, 0x24, 0x59, 0x91, 0x14, 0x59, 0x92, 0x14, 0x59, 0x91, 0x15, 0x45, 0x91, 0x15, 0x59, 0x92, 0x15, 0x59},
    {0x56, 0x64, 0x45, 0x92, 0x64, 0x45, 0x52, 0x64, 0x45, 0x56, 0x24, 0x45, 0x56, 0x14, 0x49, 0x96, 0x14, 0x45, 0x96, 0x64, 0x45, 0x92, 0x64, 0x45},
    {0x91, 0x64, 0x49, 0x52, 0x24, 0x45, 0x56, 0x24, 0x45, 0x96, 0x24, 0x49, 0x96, 0x25, 0x45, 0x92, 0x64, 0x45, 0x92, 0x64, 0x49, 0x52, 0x24, 0x45},
    {0x8e, 0xeb, 0x54, 0xee, 0xe4, 0xb8, 0xd5, 0xe4, 0xb8, 0x4e, 0xe5, 0x4e, 0x8e, 0x3b, 0x51, 0x8e, 0x3b, 0x4d, 0x4e, 0xe5, 0xb8, 0xee, 0xe4, 0xb8},
    {0xee, 0xe4, 0xb8, 0xd4, 0x34, 0x4d, 0x8e, 0xeb, 0x56, 0x4e, 0xe5, 0x4e, 0x8e, 0x3b, 0x4d, 0xee, 0xe4, 0xb8, 0xd3, 0xe4, 0x54, 0x13, 0x35, 0x51},
    {0x93, 0x3b, 0x55, 0x95, 0x33, 0xb9, 0xae, 0x33, 0xb9, 0x53, 0x35, 0x39, 0x94, 0xeb, 0x3a, 0x93, 0x4b, 0x39, 0x93, 0x3b, 0xb9, 0x93, 0x33, 0xb9},
    {0xae, 0x53, 0x4d, 0xae, 0x33, 0x39, 0x93, 0xeb, 0x3a, 0x93, 0x3b, 0x39, 0x93, 0x5b, 0x39, 0xd5, 0x33, 0xb9, 0x93, 0x33, 0xb9, 0xae, 0x33, 0x3d},
    {0x8e, 0xeb, 0x4c, 0xee, 0xe4, 0x54, 0xee, 0xe4, 0xb8, 0xce, 0xe4, 0x52, 0xc3, 0xe4, 0x52, 0x8e, 0xeb, 0x4e, 0x8e, 0x3b, 0x4c, 0xee, 0xe4, 0x54},
    {0xee, 0x34, 0x4c, 0xee, 0xe4, 0x4e, 0x8e, 0xeb, 0x56, 0x3, 0xe5, 0x4e, 0x43, 0xe5, 0x4e, 0xd5, 0xe4, 0xb8, 0xee, 0x34, 0x4c, 0x15, 0xe5, 0x4e},
    {0xcf, 0x23, 0x3c, 0x8f, 0xf3, 0x38, 0xc6, 0x20, 0x38, 0xcf, 0x63, 0x3c, 0x8e, 0xf3, 0xc, 0xc5, 0xf3, 0x3c, 0xcf, 0x23, 0x38, 0xcf, 0x23, 0x3c},
    {0xc3, 0x30, 0x3c, 0xce, 0x30, 0x38, 0xcf, 0xf3, 0xc, 0xcf, 0xf3, 0x3c, 0xcf, 0x63, 0xc, 0xc3, 0x20, 0x38, 0x8f, 0xe3, 0x38, 0xcf, 0x30, 0x3c},
    {0xc3, 0xe3, 0x38, 0xcf, 0x33, 0x38, 0xce, 0xe3, 0x18, 0x83, 0x63, 0x3c, 0xcf, 0xe3, 0x8, 0xcf, 0xf3, 0x8, 0x83, 0x33, 0x3c, 0x8e, 0xf3, 0x38},
    {0xc3, 0x33, 0x3c, 0x8f, 0x30, 0x8, 0xc3, 0x63, 0x3c, 0xc3, 0xf3, 0x3c, 0x8e, 0xf1, 0x8, 0xc3, 0xf3, 0x3c, 0x8f, 0x30, 0x3c, 0x8f, 0x31, 0x8},
    {0x82, 0x20, 0x18, 0x8f, 0x53, 0x8, 0x8f, 0xf3, 0x3c, 0x82, 0xe0, 0x3c, 0xcf, 0xf3, 0x3c, 0xc2, 0xf3, 0x3c, 0x8f, 0x21, 0x3c, 0xcf, 0x23, 0x3c},
    {0x8f, 0xf0, 0x18, 0x8e, 0xf1, 0x3c, 0x8e, 0xe3, 0x8, 0xcf, 0x63, 0x38, 0xcf, 0xf3, 0x8, 0x8f, 0xf3, 0x38, 0x8f, 0xf3, 0x38, 0x8f, 0xf3, 0x3c},
    {0xd7, 0x5e, 0x5b, 0xd7, 0x65, 0x5d, 0x56, 0x6d, 0x5d, 0x56, 0x6d, 0x5d, 0x57, 0x6d, 0x5d, 0xd6, 0x6e, 0xd5, 0xd6, 0x6e, 0xd5, 0xd6, 0x6e, 0x5d},
    {0x97, 0x65, 0x59, 0x57, 0x6d, 0x59, 0xd6, 0x55, 0x5b, 0xd6, 0x5e, 0x5b, 0xb5, 0xb5, 0x5b, 0xd6, 0x55, 0x5b, 0x96, 0x75, 0xed, 0x96, 0xb5, 0x5f},
    {0xd6, 0x6e, 0x59, 0xfb, 0x7e, 0xed, 0xb5, 0x75, 0xed, 0xbb, 0x65, 0x5d, 0x96, 0x75, 0x5d, 0x96, 0x55, 0x5b, 0xd6, 0x6e, 0xd5, 0xd6, 0x65, 0xd5},
    {0x97, 0x65, 0x59, 0x75, 0x6d, 0x5d, 0xf5, 0x7e, 0xd5, 0xd6, 0x6e, 0xed, 0x97, 0x65, 0x59, 0xfb, 0x65, 0xed, 0xb5, 0x75, 0x59, 0x96, 0x75, 0x59},
    {0xd6, 0x75, 0x5d, 0x92, 0x74, 0x59, 0x51, 0x14, 0x45, 0xd6, 0x2e, 0x49, 0x91, 0x24, 0x45, 0x96, 0x24, 0x45, 0x92, 0x64, 0x49, 0x52, 0x64, 0x49},
    {0xd2, 0x15, 0x49, 0xd2, 0x25, 0x49, 0x91, 0x24, 0x59, 0x52, 0x24, 0x49, 0x91, 0x14, 0x59, 0x91, 0x24, 0x45, 0x92, 0x14, 0x45, 0x52, 0x24, 0x45},
    {0x58, 0x16, 0x68, 0x1, 0x16, 0x68, 0x1a, 0x16, 0x68, 0x59, 0x10, 0x64, 0x59, 0xa0, 0x61, 0x41, 0x10, 0x4, 0x58, 0x90, 0x69, 0x9a, 0x16, 0x60},
    {0x58, 0x16, 0x60, 0x41, 0x10, 0x64, 0x41, 0xa6, 0x5, 0x59, 0xa0, 0x69, 0x99, 0x96, 0x5, 0x58, 0x90, 0x65, 0x5a, 0x90, 0x5, 0x18, 0x86, 0x65},
    {0x41, 0x80, 0x5, 0x58, 0xa6, 0x5, 0x99, 0x86, 0x5, 0x58, 0xa6, 0x61, 0x58, 0x10, 0x4, 0x81, 0x16, 0x64, 0x1, 0x16, 0x60, 0x9a, 0x86, 0x65},
    {0x41, 0x10, 0x60, 0x5a, 0xa6, 0x5, 0x18, 0x96, 0x5, 0x59, 0x10, 0x4, 0x41, 0x10, 0x68, 0x5a, 0x16, 0x60, 0x81, 0x86, 0x69, 0x5a, 0xa0, 0x5},
    {0x41, 0x90, 0x69, 0x59, 0x96, 0x69, 0x5a, 0x90, 0x69, 0x99, 0x16, 0x64, 0x59, 0x10, 0x60, 0x81, 0x96, 0x65, 0x41, 0xa6, 0x5, 0x5a, 0x10, 0x4},
    {0x41, 0x16, 0x68, 0x5a, 0x80, 0x69, 0x41, 0xa6, 0x5, 0x58, 0x80, 0x5, 0x19, 0xa6, 0x5, 0x1, 0xa6, 0x5, 0x1a, 0x96, 0x69, 0x19, 0x96, 0x69},
    {0x5c, 0xc7, 0x71, 0x1d, 0xc7, 0x71, 0xdc, 0xc6, 0x71, 0x1c, 0xd7, 0x71, 0x1c, 0xc7, 0x75, 0x1c, 0xc7, 0x71, 0x1d, 0xc7, 0x6d, 0x5c, 0xc7, 0x75},
    {0x1c, 0xd7, 0x71, 0x5d, 0xd7, 0x71, 0x1d, 0xb7, 0x71, 0x5c, 0xd7, 0x71, 0x1d, 0xd7, 0x75, 0x1d, 0xc7, 0x71, 0x5c, 0xd7, 0x6d, 0x1c, 0xc7, 0x75},
    {0x1d, 0xc7, 0x11, 0x1d, 0xc7, 0x75, 0x1c, 0xc7, 0x71, 0x1b, 0xc7, 0x75, 0x1c, 0xc7, 0x75, 0x1c, 0xc7, 0x71, 0xdc, 0xc6, 0x71, 0x5c, 0xc7, 0x71},
    {0x1c, 0xc7, 0x75, 0x1d, 0xb7, 0x71, 0x1c, 0xc7, 0x71, 0x1c, 0xd7, 0x71, 0x1d, 0xc7, 0x71, 0x1c, 0xc7, 0x75, 0x5b, 0xc7, 0x75, 0x5c, 0xc7, 0x71},
    {0x1d, 0xc7, 0x6d, 0x1c, 0xd7, 0x71, 0x1b, 0xc7, 0x75, 0x1c, 0xc7, 0x75, 0x5d, 0xc7, 0x71, 0x1d, 0xd7, 0x71, 0x1c, 0xc7, 0x6d, 0x1c, 0xd7, 0x71},
    {0x1c, 0xc7, 0x71, 0x5d, 0xc7, 0x71, 0x1d, 0xc7, 0x71, 0x1c, 0xc7, 0x75, 0x5c, 0xc7, 0x75, 0xdc, 0xd6, 0x71, 0x1d, 0xc7, 0x71, 0x5c, 0xc7, 0x75},
    {0xf6, 0x6e, 0xbd, 0xb6, 0xf0, 0x5d, 0x97, 0x64, 0xfd, 0x56, 0xf5, 0xf5, 0xb6, 0xdd, 0x4b, 0x56, 0x7f, 0x9, 0xfd, 0x65, 0xd9, 0xfd, 0xbf, 0xff},
    {0x51, 0x64, 0xbd, 0x62, 0x24, 0xbd, 0xbd, 0x7d, 0x59, 0xd6, 0xdb, 0x83, 0xdf, 0x25, 0x46, 0x92, 0x64, 0xd9, 0xfb, 0x65, 0x5d, 0xa2, 0x24, 0x55},
    {0xd1, 0x25, 0x89, 0xf6, 0x1f, 0xd9, 0xd7, 0x65, 0xff, 0x91, 0xd8, 0xdb, 0xdf, 0x6b, 0x5b, 0x3d, 0x78, 0x59, 0xd1, 0x25, 0x89, 0xfd, 0xdf, 0xff},
    {0x91, 0x10, 0xbd, 0xbd, 0x15, 0x59, 0x92, 0x78, 0x9, 0x91, 0xf8, 0x5d, 0xb6, 0xdd, 0x5b, 0x51, 0xf5, 0xf5, 0xbb, 0x15, 0x55, 0x9f, 0x15, 0x59},
    {0x56, 0x64, 0x45, 0x92, 0x64, 0x45, 0x52, 0x64, 0x45, 0x56, 0x24, 0x45, 0x56, 0x14, 0x49, 0x96, 0x14, 0x45, 0x96, 0x64, 0x45, 0x92, 0x64, 0x45},
    {0x91, 0x64, 0x49, 0x52, 0x24, 0x45, 0x56, 0x24, 0x45, 0x96, 0x24, 0x49, 0x96, 0x25, 0x45, 0x92, 0x64, 0x45, 0x92, 0x64, 0x49, 0x52, 0x24, 0x45},
    {0xde, 0x37, 0xc, 0xc3, 0xf7, 0x3d, 0xc3, 0x10, 0xc, 0xdf, 0xe7, 0x7d, 0xdf, 0x13, 0xc, 0xdf, 0xe7, 0x7d, 0xdf, 0xf3, 0x7d, 0xde, 0xf7, 0x7d},
    {0xde, 0xe7, 0x7d, 0xde, 0x37, 0x7c, 0xde, 0xe7, 0x7d, 0x43, 0x30, 0x7c, 0xde, 0xe7, 0x7d, 0xc3, 0x30, 0x4, 0xc3, 0xf7, 0xd, 0x43, 0xe0, 0x7d},
    {0xde, 0xe7, 0x7d, 0xde, 0xe7, 0x7d, 0xde, 0xe7, 0xd, 0xde, 0xe7, 0x7d, 0xde, 0x10, 0xc, 0xde, 0x30, 0xc, 0xc1, 0x13, 0xc, 0xc3, 0xeb, 0x7d},
    {0xde, 0xe7, 0xd, 0x41, 0x30, 0xc, 0x43, 0xf0, 0xbc, 0xc3, 0xf3, 0xbc, 0xde, 0xe7, 0xf1, 0xcf, 0xeb, 0x7d, 0x1e, 0xef, 0x7d, 0x1e, 0xef, 0xf1},
    {0x9f, 0xf7, 0x79, 0x86, 0xf7, 0x79, 0x86, 0xf7, 0x7a, 0x9f, 0x67, 0x78, 0xaf, 0x17, 0x4, 0xaf, 0x67, 0x40, 0x6f, 0xf0, 0x7a, 0x50, 0xf0, 0x7a},
    {0x86, 0x7, 0x79, 0x86, 0x17, 0x40, 0x6f, 0x60, 0x78, 0x41, 0x60, 0x4, 0xaf, 0x67, 0x78, 0x81, 0xf7, 0x42, 0x86, 0x17, 0x4, 0x90, 0x7, 0x79},
    {0x56, 0x14, 0xec, 0x92, 0x64, 0x49, 0xa2, 0x64, 0x45, 0x81, 0x14, 0x45, 0x81, 0x14, 0x45, 0x56, 0x24, 0x4a, 0xbb, 0x14, 0x48, 0x52, 0xb4, 0x47},
    {0x81, 0x14, 0x48, 0x12, 0x1c, 0x48, 0xbb, 0xa4, 0x8b, 0x41, 0x24, 0x45, 0x41, 0x24, 0x45, 0x41, 0x34, 0x58, 0x22, 0x13, 0x48, 0x96, 0x15, 0x44},
    {0x51, 0xa4, 0x4b, 0x96, 0x25, 0x89, 0xe2, 0x6e, 0x59, 0x81, 0xc4, 0x58, 0x22, 0x3c, 0xec, 0x52, 0x24, 0x5a, 0x83, 0x25, 0x4a, 0xc3, 0xe, 0x5b},
    {0x81, 0x15, 0x58, 0x91, 0x15, 0x58, 0x8e, 0x24, 0x5a, 0x81, 0xe3, 0x58, 0xa2, 0x14, 0x59, 0x81, 0x15, 0x45, 0xa2, 0x15, 0x58, 0x92, 0x15, 0x58},
    {0x41, 0x10, 0x4, 0x30, 0x1c, 0x4, 0x30, 0xdc, 0x34, 0x41, 0x20, 0xc1, 0xcd, 0xd4, 0x34, 0x1, 0xc, 0x37, 0x70, 0xa5, 0xc3, 0x70, 0x13, 0x88},
    {0x52, 0xd0, 0xc0, 0x70, 0x0, 0x37, 0xd, 0xc, 0x7, 0xb0, 0xde, 0x4c, 0xd, 0x1c, 0x5, 0xd, 0xc, 0x37, 0x30, 0xc, 0x37, 0x30, 0x2c, 0x8a},
    {0x7, 0xf4, 0x4, 0x4f, 0x1, 0x82, 0xe, 0xf4, 0x1c, 0x20, 0x18, 0x4, 0x81, 0x30, 0x14, 0x61, 0x18, 0x4, 0x45, 0x11, 0x86, 0x81, 0x10, 0xa},
    {0x60, 0x18, 0x16, 0x60, 0x18, 0x16, 0x85, 0x1, 0x81, 0xa1, 0x10, 0x4, 0xa1, 0x0, 0x81, 0x50, 0x51, 0x4, 0x41, 0x0, 0x39, 0x3, 0x4, 0x9},
    {0x21, 0x14, 0x1e, 0xd0, 0x11, 0x16, 0x7, 0x54, 0x80, 0x20, 0x74, 0x8, 0x87, 0x20, 0x40, 0x46, 0x51, 0x40, 0x87, 0x61, 0xc, 0x46, 0xe1, 0x14},
    {0x21, 0x4, 0xa, 0xc5, 0x11, 0x42, 0xcf, 0xf0, 0x3c, 0xe1, 0xe0, 0x3c, 0xcf, 0x23, 0x84, 0xd0, 0xf3, 0x3c, 0x45, 0x8, 0x3d, 0x45, 0x8, 0x85},
    {0x61, 0x18, 0x86, 0x50, 0x1, 0x86, 0x50, 0x71, 0x14, 0x20, 0x78, 0x40, 0x45, 0x1, 0x15, 0x21, 0x68, 0x14, 0x45, 0x11, 0x42, 0x86, 0x11, 0x42},
    {0x47, 0x58, 0x1c, 0x50, 0x28, 0x8, 0xc2, 0x71, 0x80, 0x47, 0x61, 0x18, 0x10, 0x4, 0x82, 0x42, 0x21, 0x8, 0x47, 0x71, 0x1c, 0x46, 0x51, 0x80},
    {0x7a, 0xac, 0x37, 0x4c, 0xac, 0x37, 0x4c, 0xac, 0xc7, 0x22, 0xb3, 0x2c, 0x7a, 0xb3, 0xc4, 0x62, 0xbc, 0x30, 0x7a, 0x2c, 0x32, 0x4c, 0x2c, 0x32},
    {0xa2, 0x28, 0x36, 0xb1, 0x28, 0x32, 0x7a, 0xc3, 0x88, 0x62, 0x13, 0x2f, 0x7a, 0xc3, 0x88, 0xe2, 0xa2, 0x37, 0x31, 0x23, 0x36, 0xc, 0x23, 0x2e},
    {0x22, 0x23, 0x32, 0x4d, 0x2c, 0x32, 0x8d, 0x1e, 0x33, 0x62, 0xdc, 0xe8, 0x4b, 0xdc, 0xc4, 0xcc, 0xd2, 0xe8, 0xb, 0xb3, 0x30, 0x4d, 0x1c, 0x33},
    {0xa2, 0x2e, 0xc6, 0x8d, 0x2e, 0xea, 0x4b, 0xdc, 0xe8, 0x22, 0xd3, 0xe8, 0x4c, 0x1c, 0x8b, 0xa2, 0xbe, 0x2c, 0xb1, 0x28, 0xc6, 0x8c, 0x28, 0x8a},
    {0xa2, 0x28, 0x8a, 0xc, 0x23, 0x8a, 0xcc, 0x12, 0x2f, 0xa2, 0xc8, 0x2c, 0xf1, 0xb2, 0x30, 0x22, 0xb3, 0x30, 0x41, 0x20, 0xc6, 0x31, 0x23, 0xc6},
    {0x8c, 0x18, 0x33, 0xb1, 0x18, 0x33, 0x1, 0xc3, 0x88, 0x41, 0xc0, 0x30, 0x71, 0x1c, 0x8b, 0x4c, 0x1c, 0x2f, 0x4c, 0x1c, 0xc7, 0x4c, 0xcc, 0xc4},
    {0x36, 0x3b, 0x8e, 0x36, 0x3b, 0xde, 0x63, 0x49, 0x8e, 0x23, 0x69, 0x8f, 0x23, 0x3b, 0x96, 0xe4, 0x68, 0x8f, 0x63, 0xc9, 0x8e, 0xa3, 0x3d, 0x8e},
    {0x24, 0x39, 0x8e, 0xe4, 0x38, 0x8e, 0x65, 0x39, 0x96, 0xe4, 0x38, 0x92, 0x23, 0x39, 0x8e, 0xe3, 0x38, 0x8e, 0xf2, 0x28, 0x8f, 0x23, 0x39, 0x92},
    {0xa3, 0x3c, 0x8e, 0xe5, 0x38, 0x96, 0x23, 0x39, 0x8e, 0xe3, 0x38, 0x8e, 0xe3, 0xc8, 0x8e, 0xf6, 0x38, 0x8e, 0xa4, 0x3d, 0x96, 0xe3, 0x38, 0x8e},
    {0xe3, 0x38, 0x8e, 0x36, 0x39, 0x8e, 0xe3, 0xc8, 0x8e, 0xe3, 0x38, 0x8e, 0x65, 0x69, 0x8f, 0xe3, 0x78, 0x93, 0xf6, 0x68, 0x8f, 0xe3, 0x38, 0x92},
    {0xe3, 0x48, 0x8e, 0xe4, 0x28, 0x8f, 0xe3, 0x38, 0xda, 0xe3, 0x38, 0x92, 0xe3, 0x38, 0x92, 0xe3, 0x38, 0x8e, 0x23, 0x3b, 0xda, 0xf6, 0x38, 0xda},
    {0x25, 0x59, 0x8e, 0xe3, 0x48, 0x92, 0xe5, 0x38, 0x96, 0xe3, 0x38, 0x8e, 0x72, 0x39, 0x8e, 0x76, 0x49, 0xb2, 0x23, 0x1b, 0x8c, 0x65, 0x39, 0xda},
    {0xe7, 0x79, 0xa6, 0xce, 0x73, 0x1e, 0xe0, 0x99, 0xa, 0xe7, 0xf1, 0xa0, 0xc6, 0x99, 0xa6, 0xa9, 0x90, 0xa6, 0xa7, 0x73, 0xa6, 0xa7, 0xf0, 0x14},
    {0xe9, 0x99, 0x9e, 0x69, 0x9a, 0x9e, 0xa9, 0xf3, 0xa4, 0xa7, 0x50, 0x14, 0xc2, 0x71, 0x1e, 0xe9, 0xf9, 0x8, 0xe0, 0x79, 0x3e, 0xc2, 0xf3, 0xa4},
    {0x69, 0x2a, 0x9c, 0xce, 0x83, 0x1a, 0x67, 0x8a, 0x1e, 0x27, 0xfa, 0x8, 0x46, 0xa, 0xa, 0x69, 0x9a, 0xa6, 0xcf, 0x61, 0x38, 0x69, 0x61, 0x38},
    {0xa9, 0x73, 0x16, 0x69, 0xfa, 0x38, 0xa9, 0x93, 0x3e, 0xc7, 0x83, 0x16, 0x8f, 0x21, 0xa0, 0xe7, 0xf3, 0x18, 0xe, 0xf8, 0x38, 0xe7, 0x99, 0x9e},
    {0x69, 0x7a, 0x3e, 0xce, 0x79, 0x9e, 0xe7, 0xe9, 0xa4, 0x67, 0x8a, 0xa6, 0x27, 0x7a, 0x3e, 0xe9, 0x99, 0xa2, 0x50, 0x9a, 0x3a, 0x69, 0x8a, 0xa},
    {0xe9, 0xf9, 0x3c, 0x4f, 0xfa, 0x14, 0xe7, 0xf9, 0xa4, 0x60, 0x7a, 0x9e, 0xa7, 0x63, 0x1c, 0xe9, 0x79, 0x82, 0xe7, 0x73, 0xa6, 0x69, 0x8a, 0xa},
    {0xa6, 0x69, 0x3e, 0xc7, 0x53, 0x38, 0x8e, 0x29, 0x98, 0xc5, 0xac, 0x99, 0x86, 0x0, 0xd, 0xb7, 0x60, 0x3a, 0x9a, 0xa1, 0x9, 0x86, 0x39, 0x83},
    {0x8e, 0x63, 0xa, 0xa1, 0x59, 0x40, 0x8e, 0x63, 0x3a, 0x82, 0x66, 0xa, 0xa0, 0x61, 0x38, 0x86, 0xa9, 0x81, 0xda, 0x63, 0x16, 0x9a, 0xe9, 0xcc},
    {0x42, 0x1, 0x9, 0xb3, 0x63, 0x68, 0xe1, 0x6c, 0xce, 0xce, 0x61, 0x1a, 0x66, 0x51, 0x98, 0x8e, 0x60, 0x82, 0xb3, 0xf0, 0x18, 0xa6, 0xa9, 0x9},
    {0xe6, 0xec, 0x8, 0xa6, 0x29, 0xcc, 0x9a, 0x23, 0xcc, 0x82, 0x23, 0x8, 0xf3, 0x23, 0xcc, 0x90, 0x36, 0x9b, 0x26, 0xe4, 0x98, 0xc2, 0x5c, 0x14},
    {0xa6, 0x29, 0x8, 0x2, 0x64, 0x42, 0x90, 0x69, 0x9a, 0x45, 0x21, 0xcc, 0x82, 0x30, 0x9b, 0xa6, 0xe0, 0x98, 0x82, 0x60, 0x9a, 0x83, 0x63, 0xa},
    {0x8e, 0x63, 0x9a, 0xa6, 0x29, 0x8, 0x42, 0x28, 0x38, 0xa6, 0x39, 0x3c, 0xe0, 0x3c, 0x3b, 0x9a, 0x29, 0x14, 0xd0, 0x63, 0x9a, 0xce, 0x20, 0x98},
    {0x85, 0x50, 0x80, 0x85, 0x51, 0x18, 0xa1, 0x51, 0x18, 0x85, 0x10, 0x16, 0x86, 0x51, 0x18, 0x47, 0x51, 0x80, 0xa1, 0x20, 0x18, 0x42, 0x51, 0x14},
    {0x42, 0x21, 0x14, 0x86, 0x51, 0x18, 0x42, 0x51, 0x8, 0x82, 0x20, 0x14, 0xa1, 0x70, 0x14, 0x2, 0x58, 0x80, 0x82, 0x71, 0x18, 0x85, 0x20, 0x14},
    {0x85, 0x70, 0x18, 0x60, 0x51, 0x18, 0x46, 0x61, 0x1c, 0x82, 0x1, 0xa, 0x5, 0x68, 0x8, 0x5, 0x28, 0x14, 0x86, 0x1, 0x86, 0x86, 0x1, 0x1a},
    {0x82, 0x20, 0x8, 0x60, 0x61, 0x8, 0x46, 0x71, 0x8, 0x42, 0x1, 0xa, 0x60, 0x28, 0x8, 0x82, 0x50, 0x8, 0x82, 0x20, 0x14, 0x85, 0x21, 0x14},
    {0x82, 0x20, 0x18, 0x85, 0x71, 0x8, 0x5, 0x58, 0x80, 0x85, 0x60, 0x14, 0x2, 0x58, 0x8, 0x45, 0x21, 0x14, 0xc2, 0x21, 0x8, 0x21, 0x58, 0x8},
    {0x42, 0x21, 0x80, 0x86, 0x1, 0x16, 0xa0, 0x61, 0x8, 0x85, 0x70, 0x18, 0x5, 0x28, 0x14, 0xa1, 0x51, 0x18, 0x85, 0x1, 0x1a, 0x85, 0x21, 0x14},
    {0x85, 0x50, 0xe0, 0x85, 0x51, 0x18, 0xb8, 0x51, 0x18, 0x85, 0x80, 0x17, 0x86, 0x51, 0x18, 0x47, 0x51, 0xe4, 0xb8, 0x20, 0x18, 0x42, 0x51, 0x14},
    {0x42, 0x21, 0x14, 0x86, 0x51, 0x18, 0x42, 0x51, 0x8, 0x82, 0x20, 0x14, 0xb8, 0x70, 0x14, 0x2, 0x5e, 0xe0, 0x82, 0x71, 0x18, 0x85, 0x20, 0x14},
    {0x85, 0x70, 0x18, 0x79, 0x51, 0x18, 0x46, 0x61, 0x1c, 0x82, 0x81, 0xb, 0x45, 0x6e, 0x8, 0x45, 0x2e, 0x14, 0x86, 0x91, 0xe3, 0x86, 0x81, 0x1b},
    {0x82, 0x20, 0x8, 0x79, 0x61, 0x8, 0x46, 0x71, 0x8, 0x42, 0x81, 0xb, 0x39, 0x2e, 0x8, 0x82, 0x50, 0x8, 0x82, 0x20, 0x14, 0x85, 0x21, 0x14},
    {0x82, 0x20, 0x18, 0x85, 0x71, 0x8, 0x5, 0x5e, 0xe4, 0x85, 0x60, 0x14, 0x2, 0x5e, 0x8, 0x45, 0x21, 0x14, 0xc2, 0x21, 0x8, 0x78, 0x5e, 0x8},
    {0x42, 0x21, 0xe0, 0x86, 0x91, 0x17, 0xb9, 0x61, 0x8, 0x85, 0x70, 0x18, 0x45, 0x2e, 0x14, 0xb8, 0x51, 0x18, 0x85, 0x91, 0x1b, 0x85, 0x21, 0x14},
    {0x21, 0x14, 0x42, 0xa1, 0x11, 0x1a, 0x81, 0x11, 0x1a, 0x21, 0x14, 0x84, 0x86, 0x11, 0x1a, 0x41, 0x18, 0x86, 0x10, 0x4, 0x19, 0x50, 0x18, 0x86},
    {0x50, 0x8, 0x85, 0x86, 0x11, 0x1a, 0x50, 0x18, 0x42, 0x10, 0x4, 0x85, 0x10, 0x14, 0x84, 0x90, 0x11, 0x1a, 0x90, 0x11, 0x18, 0x21, 0x4, 0x85},
    {0x21, 0x14, 0x18, 0x50, 0x18, 0x1a, 0x46, 0x68, 0x4, 0x90, 0x11, 0x40, 0x21, 0x64, 0x40, 0x61, 0x8, 0x85, 0x86, 0x1, 0x41, 0x86, 0x11, 0x1a},
    {0x10, 0x4, 0x41, 0x50, 0x68, 0x40, 0x46, 0x18, 0x40, 0x50, 0x18, 0x42, 0x46, 0x0, 0x41, 0x10, 0x14, 0x42, 0x10, 0x4, 0x85, 0xa1, 0x1, 0x85},
    {0x10, 0x4, 0x19, 0xa1, 0x11, 0x40, 0xa1, 0x11, 0x42, 0x21, 0x64, 0x84, 0x50, 0x18, 0x42, 0x61, 0x8, 0x85, 0x50, 0x0, 0x41, 0x61, 0x18, 0x42},
    {0x50, 0x8, 0x5, 0x86, 0x11, 0x86, 0x86, 0x61, 0x40, 0x21, 0x14, 0x18, 0x21, 0x4, 0x85, 0x90, 0x11, 0x1a, 0xa1, 0x1, 0x19, 0xa1, 0x1, 0x85},
    {0xc4, 0x40, 0x10, 0x4, 0x41, 0x10, 0x4, 0x41, 0x10, 0x4, 0x41, 0x10, 0x4, 0x41, 0xc, 0x3, 0x41, 0x10, 0x3, 0x31, 0xc, 0xc3, 0x30, 0xc},
    {0xc3, 0x33, 0x10, 0xc4, 0x30, 0x10, 0x4, 0x41, 0xc, 0x3, 0x41, 0x10, 0x4, 0x41, 0xc, 0x3, 0x41, 0x10, 0x4, 0x31, 0x10, 0x4, 0x31, 0x10},
    {0x3, 0x31, 0x10, 0x4, 0x31, 0x10, 0x4, 0x41, 0x10, 0xf, 0x41, 0x10, 0x4, 0x41, 0xc, 0x4, 0x41, 0x10, 0x4, 0x41, 0x10, 0xc4, 0x30, 0xc},
    {0x3, 0x31, 0x10, 0x4, 0x31, 0x10, 0x4, 0x41, 0x10, 0x3, 0x41, 0x10, 0xc4, 0x30, 0xc, 0x3, 0x41, 0x10, 0xc4, 0x30, 0x10, 0xc4, 0x30, 0xc},
    {0xc3, 0x30, 0xc, 0x4, 0x31, 0xc, 0x4, 0x41, 0x10, 0xc4, 0x40, 0x10, 0x4, 0x41, 0x10, 0x3, 0x41, 0x10, 0x4, 0x31, 0x10, 0x4, 0x31, 0xc},
    {0xc4, 0x43, 0x10, 0xc4, 0x40, 0x10, 0x4, 0x41, 0xc, 0x4, 0x41, 0x10, 0x4, 0x41, 0xc, 0x4, 0x41, 0x10, 0x4, 0x41, 0x10, 0xc4, 0x30, 0xc},
    {0x34, 0x4d, 0xd3, 0x34, 0xcd, 0xb2, 0x2c, 0x4d, 0xd3, 0x34, 0xcd, 0xb2, 0x2c, 0x4b, 0xd3, 0x2b, 0xcb, 0xb2, 0x2c, 0xad, 0xae, 0xeb, 0xaa, 0xaa},
    {0xab, 0xba, 0xb2, 0xec, 0xba, 0xd2, 0x34, 0xcd, 0xae, 0x2b, 0x4d, 0xd3, 0x2c, 0xcd, 0x8e, 0x2b, 0x4b, 0xd3, 0x34, 0xbd, 0xb2, 0x2c, 0xbd, 0xb2},
    {0x2b, 0xbd, 0xb2, 0x34, 0xad, 0xb2, 0x2c, 0x4d, 0xd3, 0x2a, 0x4b, 0xd3, 0x34, 0x4d, 0xd3, 0x34, 0x4d, 0xd3, 0x34, 0x4d, 0xb3, 0xec, 0xba, 0xae},
    {0x2b, 0xbd, 0xd2, 0x34, 0xbd, 0xb2, 0x2c, 0xcb, 0xb2, 0x2b, 0xcb, 0xb2, 0xec, 0xba, 0xaa, 0x2b, 0xcb, 0xb2, 0xec, 0xba, 0xb2, 0xf4, 0xba, 0xd2},
    {0xeb, 0xba, 0xae, 0x2c, 0xbd, 0xae, 0x2c, 0x4b, 0xd3, 0xf4, 0xca, 0xb2, 0x2c, 0xcb, 0xd2, 0x2b, 0xcd, 0xb2, 0x2c, 0xab, 0xb2, 0x2c, 0xab, 0xae},
    {0xac, 0x4a, 0xd3, 0xec, 0x4a, 0xd3, 0x34, 0xcb, 0xae, 0x34, 0x4d, 0xd3, 0x34, 0x4d, 0x8f, 0x2c, 0x4d, 0xd3, 0x34, 0xcd, 0xb2, 0x34, 0xbd, 0xae},
};

static const uint16_t palette555[256] = {
    0x63df, 0x0, 0x4631, 0x6b5a, 0x7fff, 0x3e0f, 0x4e73, 0x39ce, 0x36c9, 0x2666, 0x662c, 0x55ca, 0x4568, 0x3505, 0x5ef7, 0x5ad5, 0x318c, 0x668d, 0x5a4a, 0x5947, 0x6168, 0x4d05, 0x3d87, 0x20c3, 0x2325, 0x27c6, 0x1204, 0x62f0, 0x7375, 0x6b33, 0x78e1, 0x64a1, 0x2108, 0x18c6, 0x1ca4, 0x6f68, 0x6305, 0x2100, 0x144, 0x358c, 0x5a52, 0x5232, 0x7b04, 0x7b46, 0x7fec, 0x4b0c, 0x44e5, 0x5460, 0x59a8, 0x4d68, 0x14a0, 0xc2, 0x7fe8, 0x5209, 0x39e0, 0x880, 0x6270, 0x76d3, 0x2ca3, 0x28e4, 0x58a0, 0x1193, 0xd70, 0x26e, 0x31ef, 0x0, 0x2108, 0x35ad, 0x3def, 0x1d07, 0x2529, 0x1ce7, 0x1964, 0x1123, 0x3106, 0x28e5, 0x20a4, 0x1882, 0x2d6b, 0x2d6a, 0x18c6, 0x3146, 0x2d25, 0x2ca3, 0x30a4, 0x2482, 0x1cc3, 0x1061, 0x1182, 0x11e3, 0x902, 0x3168, 0x39aa, 0x3589, 0x3c60, 0x3040, 0x1084, 0xc63, 0xc42, 0x35a4, 0x3182, 0x1080, 0xa2, 0x18c6, 0x2d29, 0x2909, 0x3d82, 0x3da3, 0x3de6, 0x2586, 0x2062, 0x2820, 0x2cc4, 0x24a4, 0x840, 0x61, 0x3de4, 0x2904, 0x1ce0, 0x440, 0x3128, 0x3969, 0x1441, 0x1462, 0x2c40, 0x8c9, 0x4a8, 0x127, 0x31ff, 0xf, 0x2118, 0x35bd, 0x3dff, 0x1d17, 0x2539, 0x1cf6, 0x1974, 0x1133, 0x3116, 0x28f5, 0x20b4, 0x1892, 0x2d7b, 0x2d7a, 0x18d6, 0x3156, 0x2d35, 0x2cb3, 0x30b4, 0x2492, 0x1cd3, 0x1071, 0x1192, 0x11f2, 0x912, 0x3178, 0x39ba, 0x3599, 0x3c70, 0x3050, 0x1094, 0xc73, 0xc52, 0x35b4, 0x3192, 0x1090, 0xb2, 0x18d5, 0x2d39, 0x2919, 0x3d92, 0x3db3, 0x3df6, 0x2596, 0x2072, 0x2830, 0x2cd4, 0x24b4, 0x850, 0x71, 0x3df4, 0x2914, 0x1cef, 0x450, 0x3138, 0x3979, 0x1451, 0x1472, 0x2c50, 0x8d9, 0x4b8, 0x137, 0x18ef, 0x7, 0x108c, 0x18ce, 0x1cef, 0xc8b, 0x108c, 0xc6b, 0xcaa, 0x889, 0x188b, 0x146a, 0x104a, 0xc49, 0x14ad, 0x14ad, 0xc6b, 0x18ab, 0x148a, 0x1449, 0x184a, 0x1049, 0xc69, 0x828, 0x8c9, 0x8e9, 0x489, 0x18ac, 0x1ccd, 0x18cc, 0x1c28, 0x1828, 0x84a, 0x429, 0x429, 0x18ca, 0x18c9, 0x848, 0x49, 0xc6a, 0x148c, 0x148c, 0x1cc9, 0x1cc9, 0x1ceb, 0x10cb, 0x1029, 0x1408, 0x146a, 0x104a, 0x428, 0x28, 0x1cea, 0x148a, 0xc67, 0x28, 0x188c, 0x1cac, 0x828, 0x829, 0x1428, 0x46c, 0x4c, 0x8b
};

static const uint32_t shadow_bits[4][6] = {
    {0x0, 0x0, 0x0, 0x0, 0x0, 0x0},
    {0xdcf3f1c0, 0xfcf070cd, 0x44101000, 0xffffffff, 0xfff00000, 0xfff00000},
    {0xa30e0e3f, 0x38f8f3a, 0xffffffff, 0x0, 0xfff, 0xfff},
    {0xffffffff, 0xffffffff, 0xffffffff, 0xffffffff, 0xffffffff, 0xffffffff},
};

static const uint32_t water_bits[3][6] = {
    {0x0, 0x0, 0x0, 0x0, 0x0, 0x0},
    {0xffffffff, 0xfff3f3cc, 0xffffcf30, 0xffffffff, 0xffffffff, 0xffffffff},
    {0xffffffff, 0xffffffff, 0xffffffff, 0xffffffff, 0xffffffff, 0xffffffff},
};



static bool in_world(int x, int y, int z)
{
    return (unsigned)x < WORLD_SIZE && (unsigned)y < WORLD_HEIGHT &&
           (unsigned)z < WORLD_SIZE;
}

/* Last voxel ends exactly at the last byte: never read a padding byte. */
static unsigned unpack5(const uint8_t *p, unsigned i)
{
    unsigned bit = i * 5, n = bit >> 3, s = bit & 7;
    unsigned v = p[n] >> s;
    if (s > 3) v |= (unsigned)p[n + 1] << (8 - s);
    return v & 31;
}

static unsigned get_block(int x, int y, int z)
{
    if (!in_world(x, y, z)) return AIR;
    return unpack5(world_bits, (y * WORLD_SIZE + x) * WORLD_SIZE + z);
}

static void put_block(int x, int y, int z, unsigned v)
{
    if (!in_world(x, y, z) || v > GOLD) return;
    unsigned bit = ((y * WORLD_SIZE + x) * WORLD_SIZE + z) * 5;
    unsigned n = bit >> 3, s = bit & 7;
    world_bits[n] = (world_bits[n] & ~(31u << s)) | (v << s);
    if (s > 3)
        world_bits[n+1] = (world_bits[n+1] & ~(31u >> (8-s))) | (v >> (8-s));
}

static uint32_t random32(void)
{
    rng ^= rng << 13; rng ^= rng >> 17; rng ^= rng << 5;
    return rng;
}

static void fill_space(int x0, int y0, int z0, int x1, int y1, int z1, int b)
{
    for (int y=y0; y<=y1; ++y)
        for (int x=x0; x<=x1; ++x)
            for (int z=z0; z<=z1; ++z) put_block(x,y,z,b);
}

static void add_tree(int x, int y, int z)
{
    fill_space(x-2,y+3,z-2,x+2,y+4,z+2,LEAVES);
    fill_space(x-1,y+5,z-1,x+1,y+5,z+1,LEAVES);
    fill_space(x-1,y+6,z,x+1,y+6,z,LEAVES);
    fill_space(x,y+6,z-1,x,y+6,z+1,LEAVES);
    fill_space(x,y,z,x,y+5,z,WOOD);
}

#define WATER_LEVEL 5

#define GRID_STEP 8
#define GRID_OFFSET (GRID_STEP / 2)
#define GRID_SIZE ((WORLD_SIZE / GRID_STEP) + 1)

// Makes a "natural" looking world with randomly generated terrain and trees
static void generate_natural(void) {
    // Add bedrock floor
    fill_space(0, 0, 0, WORLD_SIZE - 1,           0, WORLD_SIZE - 1, BEDROCK);
    fill_space(0, 1, 0, WORLD_SIZE - 1, WATER_LEVEL, WORLD_SIZE - 1, WATER);

    uint8_t grid[GRID_SIZE][GRID_SIZE];

    for(uint8_t x = 0; x < GRID_SIZE; x++) {
        for(uint8_t z = 0; z < GRID_SIZE; z++) {
            grid[x][z] = (3 + random32() % 10);
        }
    }


    for(uint8_t x = 0; x < WORLD_SIZE; x++) {
        for(uint8_t z = 0; z < WORLD_SIZE; z++) {
            uint8_t grid_x = x / GRID_STEP;
            uint8_t grid_z = z / GRID_STEP;

            uint8_t lerp_x = x - (grid_x * GRID_STEP);
            uint8_t lerp_z = z - (grid_z * GRID_STEP);

            uint16_t height = 0;

            height += grid[grid_x    ][grid_z    ] * (GRID_STEP - lerp_x) * (GRID_STEP - lerp_z);
            height += grid[grid_x + 1][grid_z    ] * (            lerp_x) * (GRID_STEP - lerp_z);
            height += grid[grid_x    ][grid_z + 1] * (GRID_STEP - lerp_x) * (            lerp_z);
            height += grid[grid_x + 1][grid_z + 1] * (            lerp_x) * (            lerp_z);

            height /= GRID_STEP * GRID_STEP;

            if(height > 3) {
                fill_space(x, 1, z, x, height - 3, z, STONE);
                fill_space(x, height - 2, z, x, height, z, DIRT);
            }
            else 
            {   
                fill_space(x, 1, z, x, height, z, DIRT);
            }
            
            if(height >= WATER_LEVEL)
                fill_space(x, height, z, x, height, z, GRASS);
        }   
    }

    // Replace dirt with sand near water blocks
    for(uint8_t y = WATER_LEVEL - 1; y <= WATER_LEVEL; y++) {
        for(uint8_t x = 0; x < WORLD_SIZE; x++) {
            for(uint8_t z = 0; z < WORLD_SIZE; z++) {
                if(get_block(x, y, z) != GRASS && get_block(x, y, z) != DIRT) continue;
                if(y >= WORLD_HEIGHT - 1) continue;
                if(get_block(x, y + 1, z) != AIR && get_block(x, y + 1, z) != WATER) continue;

                bool near_water = false;

                for(int8_t by = -1; by <= 1; by++) {
                    if(y + by < 0 || y + by >= WORLD_HEIGHT) continue;

                    for(int8_t bx = -2; bx <= 2; bx++) {
                        if(x + bx < 0 || x + bx >= WORLD_SIZE) continue;
                        
                        for(int8_t bz = -2; bz <= 2; bz++) {
                            if(z + bz < 0 || z + bz >= WORLD_SIZE) continue;

                            if(get_block(bx + x, by + y, bz + z) == WATER)
                                near_water = true;
                        }
                    }
                }

                if(near_water)
                    put_block(x, y, z, SAND);
            }
        }
    }

    //Add trees
    uint8_t tree_cnt = 12;
    for(uint8_t i = 0; i < tree_cnt; i++) {
        //uint8_t x = 2;//randInt(2, WORLD_SIZE - 2 - 1);
        //uint8_t z = 2;//randInt(2, WORLD_SIZE - 2 - 1);
        // Weird little hack I need to do since clang crashes with the above lines :(
        uint8_t x = 2 + (random32() % (WORLD_SIZE - 1 - 4));
        uint8_t z = 2 + (random32() % (WORLD_SIZE - 1 - 4));

        int8_t y = WORLD_HEIGHT - 8;

        if(get_block(x, y + 1, z) != AIR) continue;

        while(y > 0) {
            if(get_block(x, y, z) != AIR) break; 
            y--;
        }

        if(get_block(x, y, z) != GRASS) continue;

        add_tree(x, y + 1, z);
        put_block(x, y, z, DIRT);
    }

    // Replace a few stone blocks with coal
    for(uint8_t y = 1; y < WORLD_HEIGHT; y++) {
        for(uint8_t x = 0; x < WORLD_SIZE; x++) {
            for(uint8_t z = 0; z < WORLD_SIZE; z++) {
                if(get_block(x, y, z) != STONE) continue;

                int r = (random32() % 20);

                // Replace stone with coal or iron ore at a 10% chance
                if(r == 0) {
                    put_block(x, y, z, COAL_ORE);
                }
                else if(r == 1) {
                    put_block(x, y, z, IRON_ORE);
                }
            }
        }
    }

    // Center the player in the world and place them at the lowest open-air block
    player.x = WORLD_SIZE / 2;
    player.y = 0;
    player.z = WORLD_SIZE / 2;

    while(player.y < (WORLD_HEIGHT - 1)) {
        if(get_block(player.x, player.y, player.z) == AIR) break;
        player.y++;
    }
}

// Makes ths demo world with a bunch of neat little structures
static void generate_demo(void) {
    // Add grass floor
    fill_space(0, 0, 0, WORLD_SIZE - 1, 0, WORLD_SIZE - 1, GRASS);
    fill_space(32, 1, 0, WORLD_SIZE - 1, 4, 16, WATER);

    fill_space(1, 1, WORLD_SIZE - 2, 1, WORLD_HEIGHT - 1, WORLD_SIZE - 2, BRICKS);

    add_tree(8, 1, 7);
    add_tree(23, 1, 15);
    add_tree(4, 1, 26);
    add_tree(16, 1, 23);
    add_tree(28, 1, 28);

    // Build house
    fill_space(18, 0, 3, 18 + 6, 0, 3 + 6, PLANKS);
    fill_space(18, 1, 3, 18 + 6, 1, 3 + 6, WATER);
    fill_space(18 + 7, 1, 3, 18 + 7, 3, 3 + 6, BRICKS);
    fill_space(18, 1, 3 + 7, 18 + 6, 3, 3 + 7, BRICKS);

    fill_space(17, 1, 3, 17, 1, 3 + 6, SAND);

    fill_space(17, 1, 3 + 7, 17, 3, 3 + 7, SLABS);
    fill_space(18 + 7, 1, 3 + 7, 18 + 7, 3, 3 + 7, SLABS);
    fill_space(18 + 7, 1, 2, 18 + 7, 3, 2, SLABS);

    fill_space(18, 2, 3, 18, 2, 3, TNT);
    fill_space(19, 1, 3, 19, 1, 3, BOOKS);

    fill_space(18 + 6, 3, 5, 18 + 6, 3, 5, COBBLE);

    // Build another structure
    fill_space(WORLD_SIZE - 4,  1, 3, WORLD_SIZE - 4,  3, 3, SLABS);
    fill_space(WORLD_SIZE - 10, 1, 3, WORLD_SIZE - 10, 3, 3, SLABS);
    fill_space(WORLD_SIZE - 4,  1, 9, WORLD_SIZE - 4,  3, 9, SLABS);
    fill_space(WORLD_SIZE - 10, 1, 9, WORLD_SIZE - 10, 3, 9, SLABS);
    fill_space(WORLD_SIZE - 10, 4, 3, WORLD_SIZE - 4,  4, 9, SLABS);

    // Make windows on the roof
    fill_space(WORLD_SIZE - 9,  4, 4, WORLD_SIZE - 8,  4, 5, WATER);
    fill_space(WORLD_SIZE - 6,  4, 4, WORLD_SIZE - 5,  4, 5, WATER);
    fill_space(WORLD_SIZE - 9,  4, 7, WORLD_SIZE - 8,  4, 8, WATER);
    fill_space(WORLD_SIZE - 6,  4, 7, WORLD_SIZE - 5,  4, 8, WATER);

    //Build a pyramid
    for(int i = 1; i <= 8; i++) {
        uint8_t center_x = WORLD_SIZE - 1;
        uint8_t center_z = WORLD_SIZE - 1;

        fill_space(center_x - i,  9 - i, center_z - i, center_x,  9 - i, center_z, GOLD);
    }

    player.x = 21;
    player.y = 2;
    player.z = 5;
}

// Makes a flat world with a grass floor
static void generate_flat(void) {
    fill_space(0, 0, 0, WORLD_SIZE - 1, 0, WORLD_SIZE - 1, GRASS);

    player.x = WORLD_SIZE / 2;
    player.y = 1;
    player.z = WORLD_SIZE / 2;
}

static int row_width(int r)
{
    return r < 48 ? 2*(r+1) : r < 80 ? 96 : 2*(127-r);
}

static int row_offset(int r) { return row_width(r)/2-r-1; }

struct hit { int x,y,z,depth; unsigned block, face; };

/* Upstream's isometric inverse, with bounded, signed arithmetic. Trace only
 * the intersection with the 48x48x16 volume. No ray recursion or hit lists.
 * Bounded numerators are nonnegative, so C division is exact floor division.
 * Each candidate is checked against forward projection to reject the gaps
 * between a voxel's three depth phases. */
static bool trace(int row, int idx, int start, int stop, bool light,
                  unsigned skip, struct hit *h)
{
    int b = idx-row_offset(row), p = (b & 1) ? 4 : 2;
    for (int d=start; d<=stop; ++d) {
        int c = d-15;
        int nx = -2*row+3*b+2*c, ny = 2*row-2*c;
        int nz = 4*row-3*b+2*c+p;
        if (nx < 0 || ny < 0 || nz < 0 || nx >= 288 || ny >= 96 || nz >= 288)
            continue;
        int x=nx/6, y=ny/6, z=nz/6;
        if (x+z+15-y != d) continue;
        int s=row-x-2*y-z;
        int t=idx-(2*x+2*y+row_offset(row)+s);
        if ((unsigned)s > 2 || (unsigned)t > 1) continue;
        unsigned block = light ? get_block(z,y,47-x) : get_block(x,y,z);
        if (block <= skip) continue;
        h->x=x; h->y=y; h->z=z; h->depth=d; h->block=block;
        h->face = s == 2 ? 2 : t;
        return true;
    }
    return false;
}

static unsigned shadow_at(const struct hit *h)
{
#if ROCKCRAFT_SHADOWS
    if (h->face == 1) return 0; /* Right face is shaded in the artwork. */
    int x=47-h->z, y=h->y, z=h->x, d=x+z+15-y;
    struct hit sh;
    unsigned flags=0;
    if (h->face == 2) {
        int r=x+2*y+z+2, i=2*x+2*y+row_offset(r)+2;
        if (trace(r,i,0,d-1,true,WATER,&sh)) flags |= 2;
        if (trace(r,i+1,0,d-1,true,WATER,&sh)) flags |= 1;
    } else {
        int r=x+2*y+z+1, i=2*x+2*y+row_offset(r)+2;
        if (trace(r,i,0,d-1,true,WATER,&sh)) flags |= 2;
        --r; i=2*x+2*y+row_offset(r)+1;
        if (trace(r,i,0,d-1,true,WATER,&sh)) flags |= 1;
    }
    return flags;
#else
    (void)h; return 0;
#endif
}

static unsigned water_at(const struct hit *h, int row, bool right)
{
    if (get_block(h->x,h->y+1,h->z) == WATER) return 2;
    bool left_half=get_block(h->x,h->y,h->z+1)!=WATER;
    bool right_half=get_block(h->x+1,h->y,h->z)!=WATER;
    int s=row-h->x-2*h->y-h->z;
    if (s == 0) return 2;
    bool half=right ? right_half : left_half;
    if (s == 2) half |= get_block(h->x+1,h->y,h->z+1)!=WATER;
    return half ? 1 : 2;
}

static unsigned texel(unsigned block, unsigned tri, unsigned pixel)
{
    const uint8_t *p = block_tex[(block-2)*6+tri];
    unsigned bit=pixel*6, n=bit>>3, s=bit&7;
    unsigned v=p[n]>>s;
    if (s > 2) v |= (unsigned)p[n+1] << (8-s);
    return v & 63;
}

static void rgb(unsigned index, unsigned *r, unsigned *g, unsigned *b)
{
    unsigned v=palette555[index];
    *r=((v>>10)&31)*255/31; *g=((v>>5)&31)*255/31; *b=(v&31)*255/31;
}

/* Draw directly into Rockbox's existing framebuffer. At most 8 pixels of
 * native output are on the stack, irrespective of screen dimensions. */
static void span(int x, int y, const uint8_t *pixels, int n)
{
    if (y<0 || y>=VIEW_HEIGHT || x>=RB_WIDTH || x+n<=0) return;
    if (x<0) { pixels-=x; n+=x; x=0; }
    if (x+n>RB_WIDTH) n=RB_WIDTH-x;
x=x*ROCKCRAFT_SCALE+(LCD_WIDTH-RB_WIDTH*ROCKCRAFT_SCALE)/2;
    y*=ROCKCRAFT_SCALE; n*=ROCKCRAFT_SCALE;
#ifdef HAVE_LCD_COLOR
    fb_data out[8 * ROCKCRAFT_SCALE];
#elif LCD_DEPTH == 1
    uint8_t out[8 * ROCKCRAFT_SCALE];
#endif
    for (int i=0; i<n; ++i) {
        unsigned r,g,b; rgb(pixels[i/ROCKCRAFT_SCALE],&r,&g,&b);
#if ROCKCRAFT_COLOR
        out[i]=FB_RGBPACK(r,g,b);
#else
        unsigned gray=(77*r+150*g+29*b)>>8;
#if LCD_DEPTH == 2
        rb->lcd_set_foreground(LCD_BRIGHTNESS(gray));
        for (int j=0;j<ROCKCRAFT_SCALE;++j) rb->lcd_drawpixel(x+i,y+j);
#else
        static const uint8_t dither[4][4]={{0,8,2,10},{12,4,14,6},{3,11,1,9},{15,7,13,5}};
        bool white=gray > (unsigned)(dither[y&3][(x+i)&3]*16+8);
#ifdef HAVE_LCD_COLOR
        out[i]=white ? FB_RGBPACK(255,255,255) : FB_RGBPACK(0,0,0);
#else
        out[i]=white ? 0 : 1; /* Mono bit 1 draws foreground (black). */
#endif
#endif
#endif
    }
#ifdef HAVE_LCD_COLOR
    for (int j=0;j<ROCKCRAFT_SCALE;++j) rb->lcd_bitmap(out,x,y+j,n,1);
#elif LCD_DEPTH == 1
    for (int j=0;j<ROCKCRAFT_SCALE;++j) rb->lcd_mono_bitmap(out,x,y+j,n,1);
#endif
}

static void triangle(int x, int y, bool right, unsigned block, unsigned face,
                     unsigned shadow, unsigned water)
{
    unsigned tri=face*2+right, k=0;
    uint32_t sm=shadow_bits[shadow][tri], wm=water_bits[water][tri];
    for (int r=0; r<7; ++r) {
        int w=r<4 ? 2*(r+1) : 2*(7-r);
        uint8_t line[8];
        for (int i=0; i<w; ++i,++k)
            line[i]=(block>=STONE ? texel(block,tri,k) : 0) |
                    (((sm>>k)&1)*64) | (((wm>>k)&1)*128);
        span(right ? x : x-w,y+r,line,w);
    }
}

static void ui_colors(void)
{
#if LCD_DEPTH > 1
    rb->lcd_set_foreground(LCD_BLACK);
    rb->lcd_set_background(LCD_WHITE);
#endif
    rb->lcd_set_drawmode(DRMODE_SOLID);
}

static const char *const material_names[25]={
    "Air", "Water", "Stone", "Grass", "Dirt", "Cobblestone", "Planks",
    "Bricks", "Slabs", "Wood", "Leaves", "Sand", "Bookshelf", "TNT",
    "Crafting table", "Furnace", "Jukebox", "Sponge", "Gravel", "Moss stone",
    "Coal ore", "Iron ore", "Bedrock", "Iron", "Gold"
};

static void hud(void)
{
    char text[32];
    ui_colors();
    rb->lcd_set_drawmode(DRMODE_SOLID|DRMODE_INVERSEVID);
    rb->lcd_fillrect(0,(LCD_HEIGHT-16),LCD_WIDTH,16);
    rb->lcd_set_drawmode(DRMODE_SOLID);
    rb->snprintf(text,sizeof(text),"%s Y%02d %c%s",player.height ? "HEIGHT" : "GROUND",
                 player.y,'A'+slot,dirty ? "*" : "");
    rb->lcd_putsxy(0,(LCD_HEIGHT-16),text);
    rb->lcd_putsxy(0,(LCD_HEIGHT-16)+8,material_names[player.material]);
}

static void render(void)
{
    int cx=RB_WIDTH/2-8*player.x+8*player.z;
    int cy=VIEW_HEIGHT/2-8+4*player.x+4*player.z+8*player.y;
    ui_colors();
#if ROCKCRAFT_COLOR
    unsigned r,g,b; rgb(0,&r,&g,&b);
    rb->lcd_set_background(LCD_RGBPACK(r,g,b));
#endif
    rb->lcd_clear_display();
    for (int row=0; row<ROW_COUNT; ++row) {
        int sy=cy+8-row*4;
        if (sy+7<=0 || sy>=VIEW_HEIGHT) continue;
        int width=row_width(row), off=row_offset(row);
        for (int i=0; i<width; ++i) {
            bool right=((i-off)&1)!=0;
            int sx=cx-width*4+8+i*8-(right ? 8 : 0);
            if (sx+(right ? 8 : 0)<=0 || sx-(right ? 0 : 8)>=RB_WIDTH) continue;
            struct hit h, solid;
            unsigned water=0, shadow=0, block=AIR, face=0;
            if (trace(row,i,0,MAX_DEPTH,false,AIR,&h)) {
                if (h.block == WATER) {
                    water=water_at(&h,row,right);
                    if (trace(row,i,h.depth+1,MAX_DEPTH,false,WATER,&solid)) h=solid;
                }
                if (h.block >= STONE) {
                    block=h.block; face=h.face; shadow=shadow_at(&h);
                }
            }
            triangle(sx,sy,right,block,face,shadow,water);
        }
        rb->yield();
    }
    /* Always-visible cursor: dark outline and white wireframe. It identifies
     * the exact editable voxel even when that voxel is hidden by a wall. */
    int x=RB_WIDTH/2, y=VIEW_HEIGHT/2-8;
    static const int8_t edges[9][4]={
        {0,0,-8,4},{0,0,8,4},{-8,4,0,8},{8,4,0,8},
        {-8,4,-8,12},{8,4,8,12},{0,8,0,16},
        {-8,12,0,16},{8,12,0,16}
    };
    ui_colors();
    for (int k=-1; k<=0; ++k) {
#if LCD_DEPTH > 1
        rb->lcd_set_foreground(k ? LCD_BLACK : LCD_WHITE);
#else
        rb->lcd_set_drawmode(k ? DRMODE_SOLID : DRMODE_SOLID|DRMODE_INVERSEVID);
#endif
        for (int i=0; i<9; ++i)
            rb->lcd_drawline((x+edges[i][0])*ROCKCRAFT_SCALE,(y+edges[i][1])*ROCKCRAFT_SCALE+k,
                             (x+edges[i][2])*ROCKCRAFT_SCALE,(y+edges[i][3])*ROCKCRAFT_SCALE+k);
    }
    hud(); rb->lcd_update();
}

static void picker(void)
{
    int p=player.material-1;
    int cols=RB_WIDTH/20, rows=MAX(1,(LCD_HEIGHT-40)/(22*ROCKCRAFT_SCALE));
    int page_size=cols*rows;
    while (!usb) {
        ui_colors(); rb->lcd_clear_display(); rb->lcd_putsxy(0,0,"Materials");
        int first=(p==24 ? 23 : p)/page_size*page_size;
        for (int i=first; i<24 && i<first+page_size; ++i) {
            int x=2+((i-first)%cols)*20;
            int y=(16+ROCKCRAFT_SCALE-1)/ROCKCRAFT_SCALE+((i-first)/cols)*22;
            unsigned block=i+1, w=block==WATER ? 2 : 0;
            triangle(x+8,y,false,block,2,0,w); triangle(x+8,y,true,block,2,0,w);
            triangle(x+8,y+8,false,block,0,0,w); triangle(x,y+4,true,block,0,0,w);
            triangle(x+16,y+4,false,block,1,0,w); triangle(x+8,y+8,true,block,1,0,w);
            if (i==p) {
                ui_colors(); rb->lcd_drawrect((x-1)*ROCKCRAFT_SCALE,(y-1)*ROCKCRAFT_SCALE,
                                              19*ROCKCRAFT_SCALE,18*ROCKCRAFT_SCALE);
            }
        }
        ui_colors();
        rb->lcd_putsxy(0,LCD_HEIGHT-24,p==24 ? "Keep material" : material_names[p+1]);
        rb->lcd_putsxy(0,LCD_HEIGHT-16,p==24 ? "> Back" : "  Back");
        rb->lcd_putsxy(0,LCD_HEIGHT-8,"Select:pick"); rb->lcd_update();
        int a=action();
        if (a==INPUT_TAP) { if (p<24) player.material=p+1; return; }
        if (a==INPUT_BACK || a==INPUT_MENU) return;
        if (a==INPUT_LEFT && p<24) p=(p+23)%24;
        if (a==INPUT_RIGHT && p<24) p=(p+1)%24;
        if (a==INPUT_UP) p=p>=cols ? p-cols : 24;
        if (a==INPUT_DOWN) p=p==24 ? 0 : p+cols<24 ? p+cols : 24;
    }
}

static uint32_t hash_bytes(uint32_t h, const uint8_t *p, size_t n)
{
    while (n--) h=(h^*p++)*UINT32_C(16777619);
    return h;
}
static uint32_t read32(const uint8_t *p)
{
    return (uint32_t)p[0] | ((uint32_t)p[1]<<8) |
           ((uint32_t)p[2]<<16) | ((uint32_t)p[3]<<24);
}
static void write32(uint8_t *p, uint32_t v)
{
    for (int i=0;i<4;++i) p[i]=v>>(i*8);
}
#define SAVE_PATH_SIZE (sizeof(PLUGIN_GAMES_DATA_DIR) + sizeof("/rockcraft-a.bin"))
static void save_path(char *p, bool temp)
{
    rb->snprintf(p,SAVE_PATH_SIZE,PLUGIN_GAMES_DATA_DIR "/rockcraft-%c.%s",
                 'a'+slot,temp ? "tmp" : "bin");
}
static bool transfer(int fd, void *data, size_t n, bool writing)
{
    uint8_t *p=data;
    while (n) {
        ssize_t k=writing ? rb->write(fd,p,n) : rb->read(fd,p,n);
        if (k<=0) return false;
        n-=k; p+=k;
    }
    return true;
}

static bool save_world(void)
{
    char path[SAVE_PATH_SIZE], temp[SAVE_PATH_SIZE];
    uint8_t head[32]={'R','B','L','O','C','K','S','1',48,16,48};
    head[11]=player.x; head[12]=player.y; head[13]=player.z;
    head[14]=player.material; head[15]=player.height;
    write32(head+16,WORLD_BYTES);
    uint32_t hash=hash_bytes(UINT32_C(2166136261),head,20);
    write32(head+20,hash_bytes(hash,world_bits,WORLD_BYTES));
    save_path(path,false); save_path(temp,true);
    int fd=rb->open(temp,O_WRONLY|O_CREAT|O_TRUNC,0666);
    if (fd<0) return false;
    bool ok=transfer(fd,head,sizeof(head),true) &&
            transfer(fd,world_bits,WORLD_BYTES,true);
    if (rb->close(fd)<0) ok=false;
    if (ok && rb->rename(temp,path)<0) ok=false;
    if (!ok) rb->remove(temp);
    else dirty=false;
    return ok;
}

/* 0=missing, 1=valid, -1=unreadable/damaged. Called only at slot entry.
 * A damaged file is never silently replaced with a freshly generated map. */
static int load_world(void)
{
    char path[SAVE_PATH_SIZE]; uint8_t h[32], extra;
    save_path(path,false);
    if (!rb->file_exists(path)) return 0;
    int fd=rb->open(path,O_RDONLY);
    if (fd<0) return -1;
    bool ok=transfer(fd,h,sizeof(h),false);
    static const uint8_t magic[11]={'R','B','L','O','C','K','S','1',48,16,48};
    if (ok) {
        for (unsigned i=0;i<sizeof(magic);++i) if (h[i]!=magic[i]) ok=false;
        if (h[11]>=48 || h[12]>=16 || h[13]>=48 || h[14]<1 || h[14]>24 ||
            h[15]>1 || read32(h+16)!=WORLD_BYTES) ok=false;
    }
    if (ok) ok=transfer(fd,world_bits,WORLD_BYTES,false) && rb->read(fd,&extra,1)==0;
    if (rb->close(fd)<0) ok=false;
    if (ok) {
        uint32_t hash=hash_bytes(UINT32_C(2166136261),h,20);
        if (read32(h+20)!=hash_bytes(hash,world_bits,WORLD_BYTES)) ok=false;
        for (unsigned i=0;i<WORLD_SIZE*WORLD_SIZE*WORLD_HEIGHT && ok;++i)
            if (unpack5(world_bits,i)>GOLD) ok=false;
    }
    if (!ok) return -1;
    player.x=h[11]; player.y=h[12]; player.z=h[13];
    player.material=h[14]; player.height=h[15]; dirty=false;
    return 1;
}

static bool new_world(void)
{
    MENUITEM_STRINGLIST(kinds_menu,"New World",NULL,"Natural","Flat","Demo structures");
    int kind=rb->do_menu(&kinds_menu,NULL,NULL,false);
    if (kind<0 || kind>2 || usb) return false;
    rb->splash(0,"Generating...");
    rb->memset(world_bits,0,sizeof(world_bits));
    player.material=STONE; player.height=false;
    rng=(uint32_t)*rb->current_tick | 1;
    if (kind==0) generate_natural();
    else if (kind==1) generate_flat();
    else generate_demo();
    dirty=true;
    return true;
}

static void edit(void)
{
    unsigned b=get_block(player.x,player.y,player.z);
    b=(b==AIR || (b==WATER && player.material!=WATER)) ? player.material : AIR;
    put_block(player.x,player.y,player.z,b); dirty=true;
}

static bool ready;
static int sel_slot;

static int menu_cb(int action, const struct menu_item_ex *this_item,
                   struct gui_synclist *this_list)
{
    (void)this_list;
    int i=(intptr_t)this_item;
    if (action==ACTION_REQUEST_MENUITEM &&
        ((!ready && (i==0 || (i>=3 && i<=6) || i==8 || i==9)) || (ready && i==10)))
        return ACTION_EXIT_MENUITEM;
    return action;
}

/* Native Rockbox menu, shown at launch and as the in-game menu.
 * Returns true to leave the plugin. */
static bool game_menu(void)
{
    static const struct opt_items slots[]={
        {"World A",-1},{"World B",-1},{"World C",-1},{"World D",-1},{"World E",-1}};
    MENUITEM_STRINGLIST(menu,"Rockcraft",menu_cb,"Resume Game","Open World",
        "World Slot","New World","Materials","Height Mode","Save",
        "Playback Control","Save and Quit","Quit without Saving","Quit");
    int selected=0;
    bool quit=false, go=false;
    rb->lcd_setfont(FONT_UI);
    while (!go && !quit && !usb) {
        switch (rb->do_menu(&menu,&selected,NULL,false)) {
        case 0: go=true; break;
        case 1:
            if (ready && dirty && !rb->yesno_pop("Discard changes?")) break;
            slot=sel_slot;
            switch (load_world()) {
            case 1: ready=go=true; break;
            case 0: ready=go=new_world(); break;
            default: ready=false; rb->splash(HZ*2,"Save unreadable"); break;
            }
            break;
        case 2: rb->set_option("World Slot",&sel_slot,RB_INT,slots,5,NULL); break;
        case 3:
            if (dirty && !rb->yesno_pop("Discard changes?")) break;
            go=new_world();
            break;
        case 4: rb->lcd_setfont(FONT_SYSFIXED); picker(); rb->lcd_setfont(FONT_UI); break;
        case 5: rb->set_bool("Height Mode",&player.height); break;
        case 6:
        case 8:
            if (save_world()) {
                if (selected==8) quit=true;
                else rb->splash(HZ,"Saved");
            } else rb->splash(HZ*2,"Save failed");
            break;
        case 7: playback_control(NULL); break;
        case 9:
            if (!dirty || rb->yesno_pop("Discard changes?")) quit=true;
            break;
        case MENU_ATTACHED_USB: usb=true; break;
        case 10: quit=true; break;
        default: if (ready) go=true; else quit=true; break;
        }
    }
    rb->lcd_setfont(FONT_SYSFIXED);
    ui_colors();
    return quit || usb;
}

enum plugin_status plugin_start(const void *parameter)
{
    (void)parameter;
    usb=false; dirty=false;
    rb->memset(&input,0,sizeof(input)); rb->button_clear_queue();
    rb->memset(&gesture,0,sizeof(gesture));
    rb->lcd_set_viewport(NULL);
#if LCD_DEPTH > 1
    unsigned old_fg=rb->lcd_get_foreground(), old_bg=rb->lcd_get_background();
#endif
    int old_mode=rb->lcd_get_drawmode();
#if LCD_DEPTH >= 16
    fb_data *old_backdrop=rb->lcd_get_backdrop();
    rb->lcd_set_backdrop(NULL);
#endif
    #ifdef HAVE_TOUCHSCREEN
    int old_touch=rb->touchscreen_get_mode();
    rb->touchscreen_set_mode(TOUCHSCREEN_BUTTON);
#endif
    rb->lcd_setfont(FONT_SYSFIXED); backlight_ignore_timeout();
    ready=false; sel_slot=slot=0;
    if (game_menu()) ready=false;
    if (ready && !usb) render();
    while (ready && !usb) {
        int a=game_action();
        if (usb) break;
        bool redraw=true;
        int x=player.x,y=player.y,z=player.z;
        switch (a) {
        case INPUT_TAP: edit(); break;
        case INPUT_DOUBLE_UP: if (player.y<15) ++player.y; break;
        case INPUT_DOUBLE_DOWN: if (player.y>0) --player.y; break;
        case INPUT_BACK: case INPUT_DOUBLE_LEFT: picker(); break;
        case INPUT_MENU: case INPUT_DOUBLE_RIGHT: if (game_menu()) ready=false; else if (!usb) render(); break;
        case INPUT_UP:
            if (player.height) ++y; else ++x; break;
        case INPUT_DOWN:
            if (player.height) --y; else --x; break;
        case INPUT_LEFT: ++z; break;
        case INPUT_RIGHT: --z; break;
        default: redraw=false; break;
        }
        if (in_world(x,y,z) && (x!=player.x || y!=player.y || z!=player.z)) {
            /* Only movement actions may replace coordinates; menus can create
             * a new world with a different cursor position. */
            if (a>=INPUT_UP && a<=INPUT_RIGHT)
                { player.x=x; player.y=y; player.z=z; }
        }
        if (redraw && ready && !usb) render();
    }
    #ifdef HAVE_TOUCHSCREEN
    rb->touchscreen_set_mode(old_touch);
#endif
    backlight_use_settings(); rb->lcd_setfont(FONT_UI);
    rb->lcd_set_drawmode(old_mode);
#if LCD_DEPTH > 1
    rb->lcd_set_foreground(old_fg); rb->lcd_set_background(old_bg);
#endif
#if LCD_DEPTH >= 16
    rb->lcd_set_backdrop(old_backdrop);
#endif
    return usb ? PLUGIN_USB_CONNECTED : PLUGIN_OK;
}
