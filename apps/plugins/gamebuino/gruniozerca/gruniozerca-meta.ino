#include <Gamebuino-Meta.h>

/*
 * Please keep in mind:
 * The code is work in progress. Requires a lot of tidying and rewriting.
 * 
 * Enjoy,
 * Dark Archon, arhn.eu
 * 2018
 */

byte lives = 3;
short score = 0;
short topscore;
static uint16_t titleData[5126];
Image title = Image(titleData);
const uint16_t grunioData[] = {14,10,1, 1, 0xF81F, 0, 0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0x0,0x0,0x0,0xfca0,0xfca0,0xF81F,0xF81F,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x4208,0x9492,0x0,0x0,0xfca0,0xF81F,0x0,0x0,0x0,0x0,0x0,0x0,0x4208,0x0,0x2104,0x2104,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x4208,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x4208,0x0,0x0,0x0,0x0,0xF81F,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0xF81F,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0xF81F,0xF81F,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0xF81F,0xF81F,0xF81F,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0x4a49,0x4a49,0x4a49,0xF81F,0xF81F,0xF81F,0xF81F,0x4a49,0x4a49,0xF81F,0xF81F};
Image grunio = Image(grunioData);
const uint16_t grunio2Data[] = {14,10,1, 1, 0xF81F, 0, 0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0xfca0,0xfca0,0xF81F,0x0,0x0,0x0,0x0,0x0,0x0,0x4208,0x0,0x4208,0x9492,0x0,0x0,0xfca0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x4208,0x0,0x2104,0x2104,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x4208,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0xF81F,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0xF81F,0xF81F,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0xF81F,0xF81F,0xF81F,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0x4a49,0x4a49,0x4a49,0xF81F,0xF81F,0xF81F,0xF81F,0x4a49,0x4a49,0xF81F,0xF81F,0xF81F};
Image grunio2 = Image(grunio2Data);
const uint16_t didaData[] = {14,10,1, 1, 0xF81F, 0, 0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0xF81F,0xF81F,0xF81F,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xfca0,0x4208,0x9492,0xfca0,0xfca0,0xfca0,0xF81F,0xF81F,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xbb80,0xfca0,0x2104,0x2104,0xfca0,0xfca0,0xfca0,0xF81F,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xbb80,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0xbb80,0xF81F,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xffff,0xbb80,0xfca0,0xfca0,0xfca0,0xbb80,0xF81F,0xF81F,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xfca0,0xbb80,0xbb80,0xF81F,0xF81F,0xfca0,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xbb80,0xF81F,0xF81F,0xF81F,0xbb80,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xF81F,0xF81F,0xF81F,0xF81F,0xbb80,0xbb80,0xbb80,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0x92a0,0x92a0,0x92a0,0xF81F,0xF81F,0xF81F,0xF81F,0x92a0,0x92a0,0xF81F,0xF81F};
Image dida = Image(didaData);
const uint16_t dida2Data[] = {14,10,1, 1, 0xF81F, 0, 0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0xF81F,0xfca0,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xbb80,0xfca0,0x4208,0x9492,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xbb80,0xfca0,0x2104,0x2104,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xffff,0xbb80,0xfca0,0xfca0,0xfca0,0xfca0,0xbb80,0xfca0,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xfca0,0xbb80,0xbb80,0xF81F,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xbb80,0xF81F,0xF81F,0xbb80,0xfca0,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xF81F,0xF81F,0xF81F,0xbb80,0xbb80,0xbb80,0xbb80,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0x92a0,0x92a0,0x92a0,0xF81F,0xF81F,0xF81F,0xF81F,0x92a0,0x92a0,0xF81F,0xF81F};
Image dida2 = Image(dida2Data);
const uint16_t carrotData[] = {5,11,1, 1, 0xF81F, 0, 0xF81F,0xF81F,0x1460,0xF81F,0xF81F,0x1460,0x1ec0,0x1460,0x1ec0,0x1460,0xF81F,0x1460,0x1ec0,0x1460,0xF81F,0xF81F,0xF81F,0x1460,0xF81F,0xF81F,0xF81F,0xbb80,0xbb80,0xbb80,0xF81F,0xbb80,0xfca0,0xfca0,0xfca0,0xbb80,0xbb80,0xfca0,0xfca0,0xfca0,0xbb80,0xbb80,0xfca0,0xfca0,0xfca0,0xbb80,0xF81F,0xbb80,0xfca0,0xbb80,0xF81F,0xF81F,0xbb80,0xfca0,0xbb80,0xF81F,0xF81F,0xF81F,0xbb80,0xF81F,0xF81F};
Image carrot = Image(carrotData);
const uint16_t heartData[] = {5,5,1, 1, 0xF81F, 0, 0xf800,0xf800,0xF81F,0xf800,0xf800,0xf800,0xf800,0xf800,0xf800,0xf800,0xf800,0xf800,0xf800,0xf800,0xf800,0xF81F,0xf800,0xf800,0xf800,0xF81F,0xF81F,0xF81F,0xf800,0xF81F,0xF81F};
Image heart = Image(heartData);
#define gameoverData titleData   /* title, game over and credits share one buffer */
Image gameover = Image(gameoverData);
const uint16_t parsnipData[] = {5,11,1, 1, 0xF81F, 0, 0xF81F,0xF81F,0x1460,0xF81F,0xF81F,0x1460,0x1ec0,0x1460,0x1ec0,0x1460,0xF81F,0x1460,0x1ec0,0x1460,0xF81F,0xF81F,0xF81F,0x1460,0xF81F,0xF81F,0xF81F,0x9cd3,0x9cd3,0x9cd3,0xF81F,0x9cd3,0xffff,0xffff,0xffff,0x9cd3,0x9cd3,0xffff,0xffff,0xffff,0x9cd3,0x9cd3,0xffff,0xffff,0xffff,0x9cd3,0xF81F,0x9cd3,0xffff,0x9cd3,0xF81F,0xF81F,0x9cd3,0xffff,0x9cd3,0xF81F,0xF81F,0xF81F,0x9cd3,0xF81F,0xF81F};
Image parsnip = Image(parsnipData);
//backgrounds
static uint16_t bgData[5126];
Image bg = Image(bgData);
static uint16_t bg_cloudsData[20486];
Image bg_clouds = Image(bg_cloudsData);
static uint16_t bg_desertData[5126];
Image bg_desert = Image(bg_desertData);
#define creditsData titleData
Image credits = Image(creditsData);


//music
int8_t music = -1;

//ending graphics
const uint16_t grunioloopData[] = {
  14, 10, // width, height
  2, // let's just say the animation has 42 frames
  5, // frame loop
  0xF81F, // no transparency
  0, // indexed image
  0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0xfca0,0xfca0,0xF81F,0x0,0x0,0x0,0x0,0x0,0x0,0x4208,0x0,0x4208,0x9492,0x0,0x0,0xfca0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x4208,0x0,0x2104,0x2104,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x4208,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0xF81F,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0xF81F,0xF81F,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0xF81F,0xF81F,0xF81F,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0x4a49,0x4a49,0x4a49,0xF81F,0xF81F,0xF81F,0xF81F,0x4a49,0x4a49,0xF81F,0xF81F,0xF81F,
  0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0x0,0x0,0x0,0xfca0,0xfca0,0xF81F,0xF81F,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x4208,0x9492,0x0,0x0,0xfca0,0xF81F,0x0,0x0,0x0,0x0,0x0,0x0,0x4208,0x0,0x2104,0x2104,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x4208,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x4208,0x0,0x0,0x0,0x0,0xF81F,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0xF81F,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0xF81F,0xF81F,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0xF81F,0xF81F,0xF81F,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0x4a49,0x4a49,0x4a49,0xF81F,0xF81F,0xF81F,0xF81F,0x4a49,0x4a49,0xF81F,0xF81F,0xF81F
  /* all the frames go here */
};
Image grunioloop(grunioloopData);

const uint16_t didaloopData[] = {14,10,2, 6, 0xF81F, 0, 0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0xF81F,0xfca0,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xbb80,0xfca0,0x4208,0x9492,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xbb80,0xfca0,0x2104,0x2104,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xffff,0xbb80,0xfca0,0xfca0,0xfca0,0xfca0,0xbb80,0xfca0,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xfca0,0xbb80,0xbb80,0xF81F,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xbb80,0xF81F,0xF81F,0xbb80,0xfca0,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xF81F,0xF81F,0xF81F,0xbb80,0xbb80,0xbb80,0xbb80,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0x92a0,0x92a0,0x92a0,0xF81F,0xF81F,0xF81F,0xF81F,0x92a0,0x92a0,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0xF81F,0xF81F,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xfca0,0x4208,0x9492,0xfca0,0xfca0,0xfca0,0xF81F,0xfca0,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xbb80,0xfca0,0x2104,0x2104,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xbb80,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0xbb80,0xfca0,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xffff,0xbb80,0xfca0,0xfca0,0xfca0,0xbb80,0xF81F,0xfca0,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xfca0,0xbb80,0xbb80,0xF81F,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xbb80,0xF81F,0xF81F,0xbb80,0xfca0,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xF81F,0xF81F,0xF81F,0xbb80,0xbb80,0xbb80,0xbb80,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0x92a0,0x92a0,0x92a0,0xF81F,0xF81F,0xF81F,0xF81F,0x92a0,0x92a0,0xF81F,0xF81F};
Image didaloop = Image(didaloopData);

//sleeping animation
const uint16_t sleepingData[] = {22,11,2, 12, 0xF81F, 0, 0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0xF81F,0xF81F,0xF81F,0xF81F,0xfca0,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0x0,0x0,0x0,0x0,0x39e7,0x39e7,0x0,0x0,0x0,0xF81F,0xF81F,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xffff,0xffff,0xfca0,0xfca0,0x0,0x0,0x39e7,0x39e7,0x0,0x0,0x0,0x0,0xfd67,0xF81F,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xffff,0xbb80,0xbb80,0xfca0,0xfca0,0x0,0x39e7,0x0,0x0,0x0,0x0,0x0,0xfca0,0xF81F,0xfca0,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xffff,0xbb80,0xbb80,0xfca0,0xfca0,0xfca0,0xfca0,0x0,0x0,0x0,0x39e7,0x39e7,0x0,0xe420,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xffff,0xbb80,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0x0,0x0,0x0,0x0,0x0,0xdc00,0xe420,0xe420,0xbb80,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xfca0,0xfca0,0xfca0,0x9ac0,0x9ac0,0xfca0,0xfca0,0x0,0x0,0x0,0x0,0x0,0x0,0xbb80,0x0,0xbb80,0xfca0,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0xbb80,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0xF81F,0xF81F,0xbb80,0xbb80,0xbb80,0xbb80,0xce79,0xce79,0xce79,0xbb80,0xbb80,0xbb80,0xbb80,0xbb80,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0x0,0x0,0x0,0x0,0x0,0x0,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xffff,0xffff,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0xF81F,0xF81F,0xF81F,0xF81F,0xfca0,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0x0,0x0,0x0,0x0,0x39e7,0x39e7,0x0,0x0,0x0,0xF81F,0xF81F,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xffff,0xffff,0xfca0,0xfca0,0x0,0x0,0x39e7,0x39e7,0x0,0x0,0x0,0x0,0xfd67,0xF81F,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xffff,0xbb80,0xbb80,0xfca0,0xfca0,0x0,0x39e7,0x0,0x0,0x0,0x0,0x0,0xfca0,0xF81F,0xfca0,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xffff,0xbb80,0xbb80,0xfca0,0xfca0,0xfca0,0xfca0,0x0,0x0,0x0,0x39e7,0x39e7,0x0,0xe420,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xffff,0xbb80,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0x0,0x0,0x0,0x0,0x0,0xdc00,0xe420,0xe420,0xbb80,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xffff,0xfca0,0xfca0,0xfca0,0x9ac0,0x9ac0,0xfca0,0xfca0,0x0,0x0,0x0,0x0,0x0,0x0,0xbb80,0x0,0xbb80,0xfca0,0xfca0,0xfca0,0xfca0,0xffff,0xffff,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0xfca0,0xbb80,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0xF81F,0xF81F,0xbb80,0xbb80,0xbb80,0xbb80,0xce79,0xce79,0xce79,0xbb80,0xbb80,0xbb80,0xbb80,0xbb80,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F,0xF81F};
Image sleeping = Image(sleepingData);


Image* player = &grunio;
Image* veggie = &carrot;
int clouds = 0;

//Grunio's position on screen
byte gposx = 35;
byte gposy = 50;
//Grunio's acceleration
byte acc = 0;
//...and orientation
bool orient = true;
bool walk = false;
bool alive = false;
byte mode = 0;
byte color = 0;
byte vtype = 0; //veggie type
//Image player = Image(grunio);

//carrot coordinates
bool carrots = false;
byte carrotx;
byte carroty;
//intro animation lights
byte introanim = 0;
byte temps = 0;

/* The big pictures are in gruniozerca.dat on the card (tools/mkpics16.py),
 * back to back in this order. */
static uint8_t shownArt = 255;
static const uint8_t artIndex[] = {0, 1, 4};   // title, game over, credits: record in the file

static void showArt(uint8_t which) {      // 0 title, 1 game over, 2 credits
  if (shownArt == which) return;
  shownArt = which;
  if (gb_data_read("gruniozerca.dat", (uint32_t)artIndex[which] * 5126 * 2, titleData, 5126 * 2) != 5126 * 2)
    memset(titleData, 0, 5126 * 2);
}

static void loadArt() {
  static uint16_t *const art[] = {bgData, bg_desertData, bg_cloudsData};
  static const uint16_t words[] = {5126, 5126, 20486};
  static const uint32_t offs[] = {2 * 5126, 3 * 5126, 5 * 5126};
  for (uint8_t i = 0; i < 3; i++) {
    if (gb_data_read("gruniozerca.dat", offs[i] * 2, art[i], words[i] * 2) != (int)(words[i] * 2))
      memset(art[i], 0, words[i] * 2);
  }
}

void defaults(){
  lives = 3;
  score = 0;
  alive = true;
  gposx = 35;
  gposy = 50;
  color = 0;
}

byte option = 1;



void setup() {
  // put your setup code here, to run once:
 gb.begin();
 loadArt();
 topscore = gb.save.get(0);
 //pick random seed
 gb.pickRandomSeed();
 //defaults();
}

byte as = 0;

void loop() {
  // put your main code here, to run repeatedly:
  while(!gb.update());
  gb.lights.clear();
  
  //NOT IN GAME
  if(!alive){

  switch(mode){
  //TITLE SCREEN
  case 0:
    gb.display.clear();
    temps = 0;
    introanim++;
    while(temps < 4){
      if(temps % 2){
         if(introanim > 8){
          gb.lights.drawPixel(0, temps, RED);
          gb.lights.drawPixel(1, temps, BLUE);
         }else{
          gb.lights.drawPixel(0, temps, BLUE);
          gb.lights.drawPixel(1, temps, RED);
         }
      }else{
         if(introanim > 8){
          gb.lights.drawPixel(0, temps, BLUE);
          gb.lights.drawPixel(1, temps, RED);
         }else{
          gb.lights.drawPixel(0, temps, RED);
          gb.lights.drawPixel(1, temps, BLUE);
         }
      
     }
     if(introanim > 15) introanim = 0;
      temps++;
    }
    
    showArt(0);
    gb.display.drawImage(0, 0, title);
    if(music == -1) music = gb.sound.play("sfx/menu.wav");
    if (gb.buttons.pressed(BUTTON_A)) {
      mode = 1;
    }
  break;
  //Main Menu
  case 1:
    gb.display.clear();
    gb.lights.clear();
    if(!(gb.frameCount % 8)) clouds--;
    if(clouds < -239) clouds = 0;
    as++;
    gb.display.drawImage(clouds, 0, bg_clouds);
    //gb.display.drawImage(0, 50, credits, 0, 50, 80, 10);
    gb.display.setColor(BLACK);
    gb.display.println("");
    gb.display.println("  GRUNIOZERCA META");
    gb.display.println("");
    gb.display.println("    START GAME");
    gb.display.println("");
    gb.display.println("    CREDITS");
    gb.display.println("");
    gb.display.println("    QUIT");
    gb.display.println("");
    gb.display.println("    ARHN.EU 2018");
    gb.display.drawImage(0, (option==1)?15:13*option, grunio);
    if (gb.buttons.pressed(BUTTON_A)) {
      if(option == 1) defaults();
      if(option == 2) mode = 2; clouds = 0;
      if(option == 3) gb.changeGame();
      gb.sound.playOK();
    }

    if (gb.buttons.pressed(BUTTON_DOWN)) {
      option++;
      if(option > 3) option = 1;
      gb.sound.playOK();
    }

    if (gb.buttons.pressed(BUTTON_UP)) {
      option--;
      if(option < 1) option = 3;
      gb.sound.playOK();
    }
  break;
  //CREDITS
  case 2:
    gb.display.clear();
    gb.lights.clear();
    gb.display.setColor(BLACK);
    showArt(2);
    gb.display.drawImage(0, 0, credits);
    gb.display.drawImage(2, 52, sleeping);
    if(!(gb.frameCount % 150)) clouds++;
    if(clouds == 3) clouds = 0;
    gb.display.setCursorY(20);
    if(clouds == 0){
        gb.display.println("  CODE:");
        gb.display.println("    Dark Archon");
        gb.display.println("      GRAPHICS:");
        gb.display.println("        Neko");
        gb.display.println("          CONCEPT:");
        gb.display.println("            Dizzy9");
      }else if(clouds == 1){
        gb.display.println("          MUSIC BY:");
        gb.display.println("     Chip Jockey");
        gb.display.println(" Ozzed.net");
        gb.display.println("");
        gb.display.println("    ARHN.EU 2018");
      }else if(clouds == 2){
        gb.display.println(" Coded with support");
        gb.display.println(" from the fantastic");
        gb.display.println(" ARHN.EU community!");
        gb.display.println("  --- YOU ROCK! ---");
      }
    if (gb.buttons.pressed(BUTTON_A)) {
      mode = 1;
    }
    break;
  //DEAD
  case 9:
  default:
  if (!gb.sound.isPlaying(music)) {
    music = -1;
  }
  if(score > topscore){
  topscore = score;
  gb.save.set(0, topscore);
  }
    gb.display.clear();
    gb.display.setColor(WHITE);
    gb.display.setCursorY(20);
    showArt(1);
    gb.display.drawImage(0, 0, gameover);
    gb.display.printf("  YOUR SCORE: %d\n", score);
    gb.display.printf("  TOP SCORE:  %d\n", topscore);
    gb.display.println("");
    gb.display.setColor(RED);
    if(topscore == score){
      gb.display.println(" ! NEW HIGH SCORE !");
      gb.lights.fill(GREEN);
    if(music == -1) music = gb.sound.play("sfx/hiscore.wav");
    }else{
      gb.lights.fill(RED);
    if(music == -1) music = gb.sound.play("sfx/gameover.wav");
    }
    gb.display.setColor(WHITE);
    gb.display.drawImage(11, 49, grunioloop);
    gb.display.drawImage(56, 49, didaloop, didaloop.width()*-1, didaloop.height());


    if (gb.buttons.pressed(BUTTON_A)) {
      defaults();
    }

    if(gb.buttons.pressed(BUTTON_MENU)){
      mode = 0;
    }
  break;
  }
    
  //ALIVE == true
  }else{
  //remove game over sound
  gb.sound.stop(music);
  music = -1;
    
  walk = 0;
  //draw interface
  gb.display.clear();
  if(!(gb.frameCount % 8)) clouds--;
  if(clouds < -239) clouds = 0;
  gb.display.drawImage(clouds, 7, bg_clouds);
  if(score < 50){
  gb.display.drawImage(0, 7, bg);
  }else{
  gb.display.drawImage(0, 7, bg_desert);
  }

  gb.display.setCursorY(1);
  gb.display.setCursorX(1);
  //gb.display.print(lives);
  gb.display.setCursorX(score<10 ? 74 : score<100 ? 70 : 66);
  gb.display.print(score);
  gb.display.setColor(WHITE);
  gb.display.drawFastHLine(0, 7, gb.display.width());

  //drawlives
  byte temp = 0;
  while(temp < lives){
    gb.display.drawImage( temp==0 ? 1 : 1+(heart.width()+1)*temp , 1, heart);
        temp++;
  }

  if (gb.buttons.repeat(BUTTON_LEFT, 0)) {
    orient = true;
    walk = true;
    if(gposx > 0){
      acc++;
      if(acc > 5){
        gposx -= 2;
      }else{
        gposx--;
      }
    }

    if(gposx > gb.display.width()) gposx = 0;
  }
  

  if (gb.buttons.repeat(BUTTON_RIGHT, 0)) {
    orient = false;
    walk = true;
    if(gposx < gb.display.width()-grunio.width()){
      acc++;
      if(acc > 5 && gposx > 1){
        gposx += 2;
      }else{
        gposx++;
      }
    }
  }

  //set grunio color
  if(gb.buttons.pressed(BUTTON_A)){
    color++;
    if(color > 1) color = 0;
  }

    
    switch(color){
      case 0:
      default:
      player = &((gb.frameCount % 2 && walk)?grunio:grunio2);
      break;
      case 1:
      player = &((gb.frameCount % 2 && walk)?dida:dida2);
      break;
    }

  //animate carrots
  if(!carrots){
    carrots = true;
    carroty = 8;
    carrotx  = rand() % (gb.display.width()-carrot.width());
    vtype = rand() % 2;
  }else{
    carroty++;
    if(score > 49) carroty++;
    //life lost
    if(carroty > gb.display.height()-carrot.height()){
      carrots = false;
      lives--;
      gb.sound.playCancel();
    }
  }

  //veggie type
    switch(vtype){
      case 0:
      default:
      veggie = &carrot;
      gb.lights.fill(ORANGE);
      break;
      case 1:
      veggie = &parsnip;
      gb.lights.fill(WHITE);
      break;
    }

 //Grunio eats veggie
  if(vtype == color &&(carrotx+carrot.width() > gposx && carrotx < gposx + grunio.width()) && carroty >= gposy-carrot.height()){
    score++;
    carrots = false;
    gb.sound.playOK();
  }
  
  gb.display.drawImage(carrotx, carroty, *veggie);
if(gposx > gb.display.width()-grunio.width()) gposx = gb.display.width()-grunio.width();

  //reset acceleration
  if(gb.buttons.released(BUTTON_LEFT) || gb.buttons.released(BUTTON_RIGHT)) acc = 0;

  //draw grunio
  //position x, position y, [Every second frame when walking toggle walking animation], orient grunio to button pressed
  gb.display.drawImage(gposx, gposy, *player, (orient)?(grunio.width()*-1):grunio.width(), grunio.height());

  //no lives left
  if(lives < 1 || gb.buttons.pressed(BUTTON_MENU)){ alive = false; mode = 9; }
  }
  
}
